* NGSPICE file created from sub_module16.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_2 abstract view
.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_2 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_2 abstract view
.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_4 abstract view
.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_2 abstract view
.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_2 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_4 abstract view
.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_2 abstract view
.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311oi_2 abstract view
.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_4 abstract view
.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32ai_4 abstract view
.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_2 abstract view
.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_2 abstract view
.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_2 abstract view
.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_4 abstract view
.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_2 abstract view
.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
.ends

.subckt sub_module16 VGND VPWR addr1[0] addr1[1] addr1[2] addr1[3] addr1[4] addr2[0]
+ addr2[1] addr2[2] addr2[3] addr2[4] addr3[0] addr3[1] addr3[2] addr3[3] addr3[4]
+ addr4[0] addr4[1] addr4[2] addr4[3] addr4[4] addr5[0] addr5[1] addr5[2] addr5[3]
+ addr5[4] addr6[0] addr6[1] addr6[2] addr6[3] addr6[4] addr7[0] addr7[1] addr7[2]
+ addr7[3] addr7[4] addr8[0] addr8[1] addr8[2] addr8[3] addr8[4] clk data1[0] data1[1]
+ data1[2] data1[3] data1[4] data1[5] data1[6] data1[7] data2[0] data2[1] data2[2]
+ data2[3] data2[4] data2[5] data2[6] data2[7] data3[0] data3[1] data3[2] data3[3]
+ data3[4] data3[5] data3[6] data3[7] data4[0] data4[1] data4[2] data4[3] data4[4]
+ data4[5] data4[6] data4[7] data5[0] data5[1] data5[2] data5[3] data5[4] data5[5]
+ data5[6] data5[7] data6[0] data6[1] data6[2] data6[3] data6[4] data6[5] data6[6]
+ data6[7] data7[0] data7[1] data7[2] data7[3] data7[4] data7[5] data7[6] data7[7]
+ data8[0] data8[1] data8[2] data8[3] data8[4] data8[5] data8[6] data8[7] en final_sum1[0]
+ final_sum1[10] final_sum1[11] final_sum1[12] final_sum1[1] final_sum1[2] final_sum1[3]
+ final_sum1[4] final_sum1[5] final_sum1[6] final_sum1[7] final_sum1[8] final_sum1[9]
+ final_sum2[0] final_sum2[10] final_sum2[11] final_sum2[12] final_sum2[1] final_sum2[2]
+ final_sum2[3] final_sum2[4] final_sum2[5] final_sum2[6] final_sum2[7] final_sum2[8]
+ final_sum2[9] final_sum3[0] final_sum3[10] final_sum3[11] final_sum3[12] final_sum3[1]
+ final_sum3[2] final_sum3[3] final_sum3[4] final_sum3[5] final_sum3[6] final_sum3[7]
+ final_sum3[8] final_sum3[9] final_sum4[0] final_sum4[10] final_sum4[11] final_sum4[12]
+ final_sum4[1] final_sum4[2] final_sum4[3] final_sum4[4] final_sum4[5] final_sum4[6]
+ final_sum4[7] final_sum4[8] final_sum4[9] final_sum5[0] final_sum5[10] final_sum5[11]
+ final_sum5[12] final_sum5[1] final_sum5[2] final_sum5[3] final_sum5[4] final_sum5[5]
+ final_sum5[6] final_sum5[7] final_sum5[8] final_sum5[9] final_sum6[0] final_sum6[10]
+ final_sum6[11] final_sum6[12] final_sum6[1] final_sum6[2] final_sum6[3] final_sum6[4]
+ final_sum6[5] final_sum6[6] final_sum6[7] final_sum6[8] final_sum6[9] final_sum7[0]
+ final_sum7[10] final_sum7[11] final_sum7[12] final_sum7[1] final_sum7[2] final_sum7[3]
+ final_sum7[4] final_sum7[5] final_sum7[6] final_sum7[7] final_sum7[8] final_sum7[9]
+ final_sum8[0] final_sum8[10] final_sum8[11] final_sum8[12] final_sum8[1] final_sum8[2]
+ final_sum8[3] final_sum8[4] final_sum8[5] final_sum8[6] final_sum8[7] final_sum8[8]
+ final_sum8[9] out1[10] out1[1] out1[2] out1[3] out1[4] out1[5] out1[6] out1[7] out1[8]
+ out1[9] out1_2[10] out1_2[1] out1_2[2] out1_2[3] out1_2[4] out1_2[5] out1_2[6] out1_2[7]
+ out1_2[8] out1_2[9] out1_3[0] out1_3[10] out1_3[1] out1_3[2] out1_3[3] out1_3[4]
+ out1_3[5] out1_3[6] out1_3[7] out1_3[8] out1_3[9] out1_4[10] out1_4[1] out1_4[2]
+ out1_4[3] out1_4[4] out1_4[5] out1_4[6] out1_4[7] out1_4[8] out1_4[9] out1_5[10]
+ out1_5[1] out1_5[2] out1_5[3] out1_5[4] out1_5[5] out1_5[6] out1_5[7] out1_5[8]
+ out1_5[9] out1_6[0] out1_6[10] out1_6[1] out1_6[2] out1_6[3] out1_6[4] out1_6[5]
+ out1_6[6] out1_6[7] out1_6[8] out1_6[9] out1_7[0] out1_7[10] out1_7[1] out1_7[2]
+ out1_7[3] out1_7[4] out1_7[5] out1_7[6] out1_7[7] out1_7[8] out1_7[9] out1_8[10]
+ out1_8[1] out1_8[2] out1_8[3] out1_8[4] out1_8[5] out1_8[6] out1_8[7] out1_8[8]
+ out1_8[9] out2[0] out2[10] out2[1] out2[2] out2[3] out2[4] out2[5] out2[6] out2[7]
+ out2[8] out2[9] out2_2[0] out2_2[10] out2_2[1] out2_2[2] out2_2[3] out2_2[4] out2_2[5]
+ out2_2[6] out2_2[7] out2_2[8] out2_2[9] out2_3[0] out2_3[10] out2_3[1] out2_3[2]
+ out2_3[3] out2_3[4] out2_3[5] out2_3[6] out2_3[7] out2_3[8] out2_3[9] out2_4[0]
+ out2_4[10] out2_4[1] out2_4[2] out2_4[3] out2_4[4] out2_4[5] out2_4[6] out2_4[7]
+ out2_4[8] out2_4[9] out2_5[0] out2_5[10] out2_5[1] out2_5[2] out2_5[3] out2_5[4]
+ out2_5[5] out2_5[6] out2_5[7] out2_5[8] out2_5[9] out2_6[0] out2_6[10] out2_6[1]
+ out2_6[2] out2_6[3] out2_6[4] out2_6[5] out2_6[6] out2_6[7] out2_6[8] out2_6[9]
+ out2_7[0] out2_7[10] out2_7[1] out2_7[2] out2_7[3] out2_7[4] out2_7[5] out2_7[6]
+ out2_7[7] out2_7[8] out2_7[9] out2_8[0] out2_8[10] out2_8[1] out2_8[2] out2_8[3]
+ out2_8[4] out2_8[5] out2_8[6] out2_8[7] out2_8[8] out2_8[9] partial_sum14[0] partial_sum14[10]
+ partial_sum14[11] partial_sum14[12] partial_sum14[13] partial_sum14[1] partial_sum14[2]
+ partial_sum14[3] partial_sum14[4] partial_sum14[5] partial_sum14[6] partial_sum14[7]
+ partial_sum14[8] partial_sum14[9] partial_sum14_1[0] partial_sum14_1[10] partial_sum14_1[11]
+ partial_sum14_1[12] partial_sum14_1[13] partial_sum14_1[1] partial_sum14_1[2] partial_sum14_1[3]
+ partial_sum14_1[4] partial_sum14_1[5] partial_sum14_1[6] partial_sum14_1[7] partial_sum14_1[8]
+ partial_sum14_1[9] partial_sum14_2[0] partial_sum14_2[10] partial_sum14_2[11] partial_sum14_2[12]
+ partial_sum14_2[13] partial_sum14_2[1] partial_sum14_2[2] partial_sum14_2[3] partial_sum14_2[4]
+ partial_sum14_2[5] partial_sum14_2[6] partial_sum14_2[7] partial_sum14_2[8] partial_sum14_2[9]
+ partial_sum14_3[0] partial_sum14_3[10] partial_sum14_3[11] partial_sum14_3[12] partial_sum14_3[13]
+ partial_sum14_3[1] partial_sum14_3[2] partial_sum14_3[3] partial_sum14_3[4] partial_sum14_3[5]
+ partial_sum14_3[6] partial_sum14_3[7] partial_sum14_3[8] partial_sum14_3[9] partial_sum15[0]
+ partial_sum15[10] partial_sum15[11] partial_sum15[12] partial_sum15[13] partial_sum15[14]
+ partial_sum15[1] partial_sum15[2] partial_sum15[3] partial_sum15[4] partial_sum15[5]
+ partial_sum15[6] partial_sum15[7] partial_sum15[8] partial_sum15[9] partial_sum15_1[0]
+ partial_sum15_1[10] partial_sum15_1[11] partial_sum15_1[12] partial_sum15_1[13]
+ partial_sum15_1[14] partial_sum15_1[1] partial_sum15_1[2] partial_sum15_1[3] partial_sum15_1[4]
+ partial_sum15_1[5] partial_sum15_1[6] partial_sum15_1[7] partial_sum15_1[8] partial_sum15_1[9]
+ partial_sum16[0] partial_sum16[10] partial_sum16[11] partial_sum16[12] partial_sum16[13]
+ partial_sum16[14] partial_sum16[15] partial_sum16[1] partial_sum16[2] partial_sum16[3]
+ partial_sum16[4] partial_sum16[5] partial_sum16[6] partial_sum16[7] partial_sum16[8]
+ partial_sum16[9] rst sum_out1[0] sum_out1[10] sum_out1[11] sum_out1[1] sum_out1[2]
+ sum_out1[3] sum_out1[4] sum_out1[5] sum_out1[6] sum_out1[7] sum_out1[8] sum_out1[9]
+ sum_out2[0] sum_out2[10] sum_out2[11] sum_out2[1] sum_out2[2] sum_out2[3] sum_out2[4]
+ sum_out2[5] sum_out2[6] sum_out2[7] sum_out2[8] sum_out2[9] sum_out3[0] sum_out3[10]
+ sum_out3[11] sum_out3[1] sum_out3[2] sum_out3[3] sum_out3[4] sum_out3[5] sum_out3[6]
+ sum_out3[7] sum_out3[8] sum_out3[9] sum_out4[0] sum_out4[10] sum_out4[11] sum_out4[1]
+ sum_out4[2] sum_out4[3] sum_out4[4] sum_out4[5] sum_out4[6] sum_out4[7] sum_out4[8]
+ sum_out4[9] sum_out5[0] sum_out5[10] sum_out5[11] sum_out5[1] sum_out5[2] sum_out5[3]
+ sum_out5[4] sum_out5[5] sum_out5[6] sum_out5[7] sum_out5[8] sum_out5[9] sum_out6[0]
+ sum_out6[10] sum_out6[11] sum_out6[1] sum_out6[2] sum_out6[3] sum_out6[4] sum_out6[5]
+ sum_out6[6] sum_out6[7] sum_out6[8] sum_out6[9] sum_out7[0] sum_out7[10] sum_out7[11]
+ sum_out7[1] sum_out7[2] sum_out7[3] sum_out7[4] sum_out7[5] sum_out7[6] sum_out7[7]
+ sum_out7[8] sum_out7[9] sum_out8[0] sum_out8[10] sum_out8[11] sum_out8[1] sum_out8[2]
+ sum_out8[3] sum_out8[4] sum_out8[5] sum_out8[6] sum_out8[7] sum_out8[8] sum_out8[9]
+ out1[0] out1_5[0] out1_8[0] out1_4[0] out1_2[0]
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3155_ _0275_ _0459_ _0464_ _0280_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_68_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3086_ _0366_ _0400_ _0405_ _0367_ _2188_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a221o_1
XFILLER_0_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3988_ net311 net229 VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_33_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2939_ _0300_ net20 _0302_ net16 VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4609_ _1685_ _1669_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_92_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_116_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4960_ net441 net456 VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3911_ _1132_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__nor2_2
X_4891_ _1904_ _1907_ VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__xnor2_2
XFILLER_0_104_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3842_ _1078_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3773_ _1017_ _1021_ _1019_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__a21o_1
X_2724_ _0089_ _0105_ _0111_ _0095_ _0088_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2655_ _2285_ _2301_ _2332_ _2272_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput401 net401 VGND VGND VPWR VPWR partial_sum14_1[5] sky130_fd_sc_hd__buf_1
XFILLER_0_42_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput434 net434 VGND VGND VPWR VPWR partial_sum15[0] sky130_fd_sc_hd__buf_1
Xoutput423 net423 VGND VGND VPWR VPWR partial_sum14_3[12] sky130_fd_sc_hd__buf_1
Xoutput412 net412 VGND VGND VPWR VPWR partial_sum14_2[2] sky130_fd_sc_hd__buf_1
Xoutput467 net467 VGND VGND VPWR VPWR partial_sum16[12] sky130_fd_sc_hd__buf_1
Xoutput445 net445 VGND VGND VPWR VPWR partial_sum15[6] sky130_fd_sc_hd__buf_1
Xoutput456 net456 VGND VGND VPWR VPWR partial_sum15_1[2] sky130_fd_sc_hd__buf_1
Xoutput478 net478 VGND VGND VPWR VPWR partial_sum16[8] sky130_fd_sc_hd__buf_1
X_4325_ _1298_ net201 VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__xnor2_1
X_2586_ _2279_ _2288_ _2252_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput489 net489 VGND VGND VPWR VPWR sum_out1[7] sky130_fd_sc_hd__buf_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4256_ _0138_ _0202_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__and2_1
X_4187_ _1332_ _1337_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__a21o_2
X_3207_ sm2.s2.t1.A_wire\[6\] VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3138_ _0231_ _0469_ _0474_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__o22ai_4
XTAP_TAPCELL_ROW_38_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3069_ _0337_ _0411_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__a211o_1
XFILLER_0_92_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2440_ _2155_ _2104_ _2114_ _2140_ _2157_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__a221oi_1
XFILLER_0_121_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2371_ net105 VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__clkbuf_8
X_4110_ _1249_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__nand2_1
X_5090_ _2043_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4041_ _1231_ _1233_ _1230_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_91_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_108_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4943_ net423 net409 VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4874_ net160 net173 VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_129_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3825_ _1068_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__nor2_2
X_3756_ _1010_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__nand2_4
XFILLER_0_6_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2707_ _2086_ net40 _0081_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__a21o_4
X_3687_ _2141_ _0939_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_76_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2638_ _2261_ _2300_ _2313_ _2255_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__a22o_1
Xoutput231 net231 VGND VGND VPWR VPWR out1_3[1] sky130_fd_sc_hd__buf_1
Xoutput220 net220 VGND VGND VPWR VPWR out1_2[10] sky130_fd_sc_hd__buf_1
Xoutput242 net242 VGND VGND VPWR VPWR out1_4[2] sky130_fd_sc_hd__buf_1
Xoutput253 net253 VGND VGND VPWR VPWR out1_5[3] sky130_fd_sc_hd__buf_1
X_2569_ _2268_ _2273_ _2274_ _2252_ _2257_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__o32a_1
Xoutput264 net264 VGND VGND VPWR VPWR out1_6[4] sky130_fd_sc_hd__buf_1
Xoutput275 net275 VGND VGND VPWR VPWR out1_7[5] sky130_fd_sc_hd__buf_1
Xoutput286 net286 VGND VGND VPWR VPWR out1_8[6] sky130_fd_sc_hd__buf_1
X_4308_ _1438_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__inv_2
Xoutput297 net297 VGND VGND VPWR VPWR out2[6] sky130_fd_sc_hd__buf_1
X_4239_ _0130_ _0197_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3610_ _0672_ net3 _0660_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__and3_2
X_4590_ _1674_ _1676_ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__xnor2_4
X_3541_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3472_ _0768_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__and2_2
XFILLER_0_86_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5211_ clknet_3_7__leaf_clk _0047_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
X_2423_ _2123_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nor2_1
X_5142_ _2261_ net78 _2067_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5073_ _0695_ net45 _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__mux2_1
X_4024_ net291 net210 VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4926_ net432 net418 VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4857_ _2184_ _1794_ _1796_ _2186_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_82_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3808_ _1012_ _1050_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4788_ _1819_ _1825_ VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__xor2_2
X_3739_ net255 net340 VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2972_ _0320_ _0323_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__and2_2
X_4711_ _1771_ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4642_ _1717_ _1720_ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__xor2_2
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4573_ net142 net155 VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__and2_1
X_3524_ _0756_ _0816_ _0763_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_116_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3455_ _0755_ VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_4
XFILLER_0_97_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2406_ sm2.s1.t2.A_wire\[6\] VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__buf_2
X_3386_ _0673_ _0656_ _0666_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__o21a_1
X_5125_ _0117_ net102 _2056_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__mux2_1
X_5056_ _0352_ net69 _2023_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4007_ net490 _1192_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_127_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4909_ net428 net414 VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_23_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_5 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3240_ sm2.s2.t1.A_wire\[10\] _0559_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3171_ _0500_ _0496_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2955_ _0318_ VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2886_ _0226_ _0215_ _0227_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o21a_1
XFILLER_0_114_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4625_ _1705_ _1680_ _1706_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__a21o_2
X_4556_ net524 _1627_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__and2_1
X_3507_ _0756_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4487_ net139 net152 VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__and2_1
X_3438_ net11 _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_129_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3369_ _0667_ _0671_ _0674_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__or4_1
X_5108_ _0552_ net94 _2045_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_28_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5039_ _0787_ net61 _2012_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2740_ _0109_ _0100_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_109_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2671_ net36 VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__inv_2
XFILLER_0_41_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4410_ _1507_ _1511_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4341_ _1472_ _1474_ VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__xor2_2
X_4272_ _1311_ _0562_ _1313_ _0560_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__a22oi_1
X_3223_ sm2.s2.t1.A_wire\[7\] sm2.s2.t1.A_wire\[8\] _0536_ VGND VGND VPWR VPWR _0551_
+ sky130_fd_sc_hd__or3_1
XFILLER_0_118_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3154_ _0289_ _0454_ _0461_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a21o_1
X_3085_ _0353_ _0413_ _0397_ _0375_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_68_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3987_ net311 net229 VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_33_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2938_ net18 VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__buf_2
XFILLER_0_91_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2869_ _0215_ _0218_ _0236_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4608_ _1686_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_92_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4539_ net512 _1613_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_138_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4890_ _1465_ net411 VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__xnor2_2
X_3910_ net296 net215 VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3841_ _0444_ _0649_ _0650_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__and3_1
XFILLER_0_116_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3772_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nand2_2
X_2723_ _0114_ VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__inv_2
XFILLER_0_89_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2654_ _2279_ _2324_ _2313_ _2278_ _2188_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__a221o_1
Xoutput402 net402 VGND VGND VPWR VPWR partial_sum14_1[6] sky130_fd_sc_hd__buf_1
XFILLER_0_42_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2585_ _2242_ _2285_ _2278_ _2234_ _2286_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput424 net424 VGND VGND VPWR VPWR partial_sum14_3[13] sky130_fd_sc_hd__buf_1
Xoutput413 net413 VGND VGND VPWR VPWR partial_sum14_2[3] sky130_fd_sc_hd__buf_1
Xoutput435 net435 VGND VGND VPWR VPWR partial_sum15[10] sky130_fd_sc_hd__buf_1
XFILLER_0_112_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput468 net468 VGND VGND VPWR VPWR partial_sum16[13] sky130_fd_sc_hd__buf_1
Xoutput457 net457 VGND VGND VPWR VPWR partial_sum15_1[3] sky130_fd_sc_hd__buf_1
Xoutput446 net446 VGND VGND VPWR VPWR partial_sum15[7] sky130_fd_sc_hd__buf_1
X_4324_ _1460_ _1461_ VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__nor2_2
Xoutput479 net479 VGND VGND VPWR VPWR partial_sum16[9] sky130_fd_sc_hd__buf_1
XFILLER_0_129_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4255_ _1407_ _1408_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__xor2_4
X_4186_ _1336_ net570 VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__and2b_1
X_3206_ sm2.s2.t1.A_wire\[6\] _0521_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_2_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3137_ _0247_ _0463_ _0464_ _0239_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_38_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3068_ _0344_ _0400_ _0405_ _0347_ _2172_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2370_ sm2.s1.t2.A_wire\[3\] sm2.s1.t2.A_wire\[4\] VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_110_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4040_ _1241_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__inv_2
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4942_ _1944_ _1946_ _1947_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4873_ net542 _1895_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__xnor2_4
XFILLER_0_131_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3824_ net529 _1067_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__nor2_1
X_3755_ _1003_ _1008_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__or3b_1
X_3686_ _0953_ VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
X_2706_ _0099_ VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2637_ _2239_ _2328_ _2332_ _2249_ _2333_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_76_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput210 net210 VGND VGND VPWR VPWR out1[10] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_132_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput232 net232 VGND VGND VPWR VPWR out1_3[2] sky130_fd_sc_hd__buf_1
Xoutput221 net221 VGND VGND VPWR VPWR out1_2[1] sky130_fd_sc_hd__buf_1
Xoutput243 net243 VGND VGND VPWR VPWR out1_4[3] sky130_fd_sc_hd__buf_1
X_2568_ _2270_ _2228_ _2240_ _2261_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput254 net254 VGND VGND VPWR VPWR out1_5[4] sky130_fd_sc_hd__buf_1
Xoutput265 net265 VGND VGND VPWR VPWR out1_6[5] sky130_fd_sc_hd__buf_1
Xoutput276 net276 VGND VGND VPWR VPWR out1_7[6] sky130_fd_sc_hd__buf_1
X_4307_ _1449_ _1451_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__xor2_4
X_2499_ net23 VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__buf_2
Xoutput287 net287 VGND VGND VPWR VPWR out1_8[7] sky130_fd_sc_hd__buf_1
Xoutput298 net298 VGND VGND VPWR VPWR out2[7] sky130_fd_sc_hd__buf_1
X_4238_ _0130_ _0197_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__and2_1
X_4169_ net570 _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3540_ _0824_ _0825_ _0826_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__o211a_1
XFILLER_0_101_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3471_ sm1.s2.t1.A_wire\[3\] sm1.s2.t1.A_wire\[4\] _0769_ VGND VGND VPWR VPWR _0770_
+ sky130_fd_sc_hd__o21ai_1
X_5210_ clknet_3_7__leaf_clk _0046_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2422_ _2135_ _2136_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5141_ _2070_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5072_ _2011_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__buf_4
X_4023_ _1228_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__inv_2
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4925_ net432 net418 VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__or2_1
X_4856_ _1879_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_117_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3807_ _1054_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__inv_2
XFILLER_0_15_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4787_ _1041_ net179 VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3738_ _0987_ _0989_ _0990_ _0991_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_42_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3669_ _0938_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_4
XFILLER_0_113_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2971_ _0321_ _0323_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__and2_2
XFILLER_0_29_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4710_ _1550_ _1551_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4641_ _1718_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__nand2_2
XFILLER_0_98_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4572_ _1655_ _1658_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3523_ _0808_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__inv_2
XFILLER_0_122_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3454_ _0737_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2405_ _2112_ _2119_ _2125_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__nand3_2
XFILLER_0_110_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3385_ _0693_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__inv_2
X_5124_ _2061_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_5055_ _2025_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_4006_ net491 _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_127_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4908_ net428 net414 VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_23_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4839_ _2170_ _1794_ _1796_ _2168_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_105_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_6 _2083_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3170_ net34 _0497_ _0498_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__or3b_1
XFILLER_0_107_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2954_ _0299_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2885_ _0239_ _0243_ _0255_ _0216_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4624_ net526 _1677_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__and2_1
X_4555_ _1609_ _1629_ _1646_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__a21o_1
X_3506_ sm1.s2.t1.A_wire\[9\] _0794_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__xor2_4
XFILLER_0_4_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4486_ _1590_ _1591_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__nor2_4
XFILLER_0_12_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3437_ net12 VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__buf_2
XFILLER_0_0_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3368_ _2101_ _0649_ _0656_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_129_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5107_ _2052_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_3299_ _0547_ _0594_ _0605_ _0524_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_28_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5038_ _2016_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2670_ net36 net37 net40 _0065_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_124_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_113_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4340_ _1468_ _1470_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__o21ai_2
X_4271_ _1421_ VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__inv_2
X_3222_ _0531_ _0539_ _0547_ _0526_ _0529_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__a221o_1
XFILLER_0_118_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3153_ _0261_ _0469_ _0488_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__o21a_2
XFILLER_0_118_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3084_ _0431_ VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_68_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3986_ _1196_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_33_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2937_ net16 _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4607_ _1689_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__xor2_2
X_2868_ _0220_ _0236_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__and2_2
XFILLER_0_60_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2799_ _0092_ _0179_ _0166_ _0094_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_92_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4538_ _1630_ _1632_ VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4469_ net386 net400 VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_39_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_48_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3840_ _1077_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_104_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3771_ net250 net335 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__or2_1
XFILLER_0_116_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2722_ _0092_ _0100_ _0113_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ _2347_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_42_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_57_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput425 net425 VGND VGND VPWR VPWR partial_sum14_3[1] sky130_fd_sc_hd__buf_1
XFILLER_0_1_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput403 net403 VGND VGND VPWR VPWR partial_sum14_1[7] sky130_fd_sc_hd__buf_1
Xoutput414 net414 VGND VGND VPWR VPWR partial_sum14_2[4] sky130_fd_sc_hd__buf_1
XFILLER_0_22_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2584_ _2284_ _2286_ _2287_ _2252_ _2270_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__o32a_2
X_4323_ net367 net356 VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput436 net436 VGND VGND VPWR VPWR partial_sum15[11] sky130_fd_sc_hd__buf_1
Xoutput447 net447 VGND VGND VPWR VPWR partial_sum15[8] sky130_fd_sc_hd__buf_1
Xoutput469 net469 VGND VGND VPWR VPWR partial_sum16[14] sky130_fd_sc_hd__buf_1
Xoutput458 net458 VGND VGND VPWR VPWR partial_sum15_1[4] sky130_fd_sc_hd__buf_1
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4254_ _1386_ _1389_ _1384_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__o21a_2
XFILLER_0_129_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3205_ _0517_ _0531_ _0524_ _0526_ _0529_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__a221o_1
X_4185_ _1346_ _1350_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__xnor2_4
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3136_ _0255_ _0454_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_38_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3067_ _0324_ _0413_ _0397_ _0353_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3969_ net309 net227 _1163_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4941_ net422 net408 VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4872_ _1893_ _1887_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3823_ net529 _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3754_ _1003_ _1008_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__o21bai_2
XPHY_EDGE_ROW_65_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3685_ _2105_ _0945_ _0948_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__a211o_1
X_2705_ _0090_ _0096_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_119_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2636_ _2247_ _2309_ _2307_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_76_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput200 net200 VGND VGND VPWR VPWR final_sum8[12] sky130_fd_sc_hd__buf_1
XFILLER_0_42_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput233 net233 VGND VGND VPWR VPWR out1_3[3] sky130_fd_sc_hd__buf_1
Xoutput222 net222 VGND VGND VPWR VPWR out1_2[2] sky130_fd_sc_hd__buf_1
Xoutput211 net211 VGND VGND VPWR VPWR out1[1] sky130_fd_sc_hd__buf_1
Xoutput244 net244 VGND VGND VPWR VPWR out1_4[4] sky130_fd_sc_hd__buf_1
XFILLER_0_42_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2567_ _2229_ _2272_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__and2_1
Xoutput255 net255 VGND VGND VPWR VPWR out1_5[5] sky130_fd_sc_hd__buf_1
Xoutput266 net266 VGND VGND VPWR VPWR out1_6[6] sky130_fd_sc_hd__buf_1
Xoutput277 net277 VGND VGND VPWR VPWR out1_7[7] sky130_fd_sc_hd__buf_1
X_4306_ _1434_ _1436_ _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__a21o_2
X_2498_ net25 VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_263 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput288 net288 VGND VGND VPWR VPWR out1_8[8] sky130_fd_sc_hd__buf_1
Xoutput299 net299 VGND VGND VPWR VPWR out2[8] sky130_fd_sc_hd__buf_1
X_4237_ _1315_ _0111_ _1317_ _0109_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__a22o_2
XPHY_EDGE_ROW_74_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4168_ _1315_ _0085_ _1317_ _0082_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_97_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4099_ _1283_ _1285_ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__xor2_4
X_3119_ _0219_ _0447_ _0448_ _0210_ _2083_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a32o_1
XFILLER_0_65_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3470_ sm1.s2.t1.A_wire\[5\] VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2421_ sm2.s1.t2.A_wire\[7\] VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__clkbuf_4
X_5140_ _2257_ net77 _2067_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_71_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5071_ _2033_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_4022_ _1226_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__nand2_2
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4924_ _1932_ _1933_ VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__xnor2_2
XFILLER_0_59_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4855_ _1880_ _1864_ _1862_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_82_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4786_ _1822_ _1824_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__xnor2_4
XFILLER_0_74_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3806_ _1052_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__nand2_2
XFILLER_0_132_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3737_ net254 net339 VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3668_ _2090_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3599_ _2177_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2619_ _2102_ sm2.s1.t1.A_wire\[3\] _2316_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2970_ _0328_ _0331_ _0299_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4640_ net230 net313 VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__or2_2
XFILLER_0_56_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4571_ net389 net403 VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3522_ _0772_ _0809_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a21o_1
X_3453_ _0744_ _0750_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_116_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2404_ _2116_ _2104_ _2123_ _2124_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__o2bb2a_1
X_5123_ _0109_ net101 _2056_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__mux2_1
X_3384_ _0682_ _0686_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nor3_4
XFILLER_0_137_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5054_ _0344_ net68 _2023_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__mux2_1
X_4005_ _0715_ _1094_ _1096_ _0719_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4907_ net429 net415 VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4838_ _1850_ _1860_ _1865_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_23_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4769_ _1798_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
XFILLER_0_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_7 _2089_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_20_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2953_ _0307_ _0312_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__and3_2
XFILLER_0_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2884_ sm1.s1.t2.A_wire\[7\] _0245_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__xor2_4
XFILLER_0_72_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4623_ net526 _1677_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__or2_1
X_4554_ net141 net154 VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__and2_1
X_3505_ _0766_ _0789_ _0796_ _0772_ _0763_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4485_ _1587_ _1588_ _1589_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3436_ sm1.s2.t1.A_wire\[3\] VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_90_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3367_ _0675_ _0676_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_129_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5106_ _0546_ net93 _2045_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5037_ _0780_ net60 _2012_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__mux2_1
X_3298_ _2131_ _0501_ _0546_ _0590_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_56_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput100 data8[3] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_8_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ _1419_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3221_ _0522_ _0543_ _0545_ _0549_ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__o22a_4
XFILLER_0_118_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3152_ _0285_ _0454_ _0486_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a211o_1
X_3083_ _2089_ _0344_ _0429_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3985_ _1193_ _1195_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_33_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2936_ net17 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__buf_2
XFILLER_0_17_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2867_ sm1.s1.t2.A_wire\[6\] VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__buf_2
X_4606_ net238 net321 _1665_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_79_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2798_ _0102_ _0160_ _2172_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_135_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4537_ _1603_ _1606_ _1631_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__a21o_1
X_4468_ _1574_ _1575_ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__xor2_4
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3419_ _0722_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__nor2_2
X_4399_ _0842_ _0843_ net232 VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_5_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_103_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3770_ net250 net335 VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nand2_1
X_2721_ _0109_ _0083_ _0110_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a211o_1
XFILLER_0_109_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2652_ _2088_ _2257_ _2343_ _2346_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__o22a_1
XFILLER_0_112_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_112_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput415 net415 VGND VGND VPWR VPWR partial_sum14_2[5] sky130_fd_sc_hd__buf_1
Xoutput404 net404 VGND VGND VPWR VPWR partial_sum14_1[8] sky130_fd_sc_hd__buf_1
Xoutput426 net426 VGND VGND VPWR VPWR partial_sum14_3[2] sky130_fd_sc_hd__buf_1
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2583_ _2242_ _2278_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__and2_1
X_4322_ _2357_ _0148_ net356 VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__and3_2
XFILLER_0_10_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput437 net437 VGND VGND VPWR VPWR partial_sum15[12] sky130_fd_sc_hd__buf_1
Xoutput448 net448 VGND VGND VPWR VPWR partial_sum15[9] sky130_fd_sc_hd__buf_1
Xoutput459 net459 VGND VGND VPWR VPWR partial_sum15_1[5] sky130_fd_sc_hd__buf_1
XFILLER_0_22_283 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4253_ _1405_ _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__nand2_2
X_3204_ _0534_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__inv_2
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4184_ _1321_ _1348_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_2_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3135_ _0252_ _0455_ _0459_ _0233_ _0461_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_38_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_121_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3066_ _0409_ _0416_ VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__nand2_1
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3968_ _1180_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_137_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2919_ _0248_ _0255_ _0285_ _0216_ _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__a221o_1
X_3899_ _1122_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__and2_2
XFILLER_0_18_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4940_ net422 net408 VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_121_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4871_ _1882_ _1883_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3822_ _2296_ _2278_ _1028_ _2279_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__a22o_1
X_3753_ net257 net342 VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
X_3684_ _0949_ _0951_ _2090_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__o21a_1
XFILLER_0_125_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2704_ _0092_ _0083_ _0097_ _0082_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a22o_1
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2635_ _2309_ _2307_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_76_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput201 net201 VGND VGND VPWR VPWR final_sum8[1] sky130_fd_sc_hd__buf_1
XFILLER_0_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_132_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput234 net234 VGND VGND VPWR VPWR out1_3[4] sky130_fd_sc_hd__buf_1
Xoutput223 net223 VGND VGND VPWR VPWR out1_2[3] sky130_fd_sc_hd__buf_1
Xoutput212 net212 VGND VGND VPWR VPWR out1[2] sky130_fd_sc_hd__buf_1
X_4305_ _1427_ _1433_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__nor2_1
X_2566_ _2269_ _2271_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__and2_2
Xoutput245 net245 VGND VGND VPWR VPWR out1_4[5] sky130_fd_sc_hd__buf_1
Xoutput256 net256 VGND VGND VPWR VPWR out1_5[6] sky130_fd_sc_hd__buf_1
Xoutput267 net267 VGND VGND VPWR VPWR out1_6[7] sky130_fd_sc_hd__buf_1
X_2497_ _2208_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput278 net278 VGND VGND VPWR VPWR out1_7[8] sky130_fd_sc_hd__buf_1
Xoutput289 net289 VGND VGND VPWR VPWR out1_8[9] sky130_fd_sc_hd__buf_1
X_4236_ _1371_ _1391_ _1392_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__a21o_2
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4167_ _1334_ _1335_ VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__xor2_4
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3118_ _0458_ _0210_ _2094_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and3b_2
XFILLER_0_97_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4098_ _1279_ _1281_ _1284_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__a21o_1
X_3049_ _0310_ _0390_ _0393_ _0394_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a211o_1
XFILLER_0_81_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2420_ _2139_ VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__buf_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5070_ _0683_ net44 _2023_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__mux2_1
X_4021_ _1217_ _1205_ _1225_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4923_ net432 net418 VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4854_ _1861_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_82_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4785_ net547 _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__xnor2_2
X_3805_ _1049_ _1046_ _1051_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__or3b_2
X_3736_ _0994_ VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__inv_2
XFILLER_0_70_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3667_ _0935_ _0936_ _2082_ _2093_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_113_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3598_ _0749_ _0831_ _0808_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a211o_1
XFILLER_0_113_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2618_ _2291_ _2293_ _2298_ _2212_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__o211a_1
X_2549_ sm2.s1.t1.A_wire\[7\] VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4219_ _1371_ _1378_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__xnor2_4
X_5199_ clknet_3_6__leaf_clk _0035_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4570_ _1655_ _1658_ VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__xor2_1
X_3521_ _0807_ _0774_ _0801_ _0766_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3452_ _0743_ net15 _0746_ _0751_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o311a_1
XFILLER_0_110_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2403_ sm2.s1.t2.A_wire\[3\] _2105_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_110_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3383_ _0668_ _0687_ _0690_ _0657_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a221o_1
X_5122_ _2060_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5053_ _2024_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4004_ _1210_ _1211_ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_84_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4906_ _1919_ VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__inv_2
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4837_ _1060_ _1859_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_23_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4768_ _1035_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__xor2_2
X_3719_ _2186_ _0957_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_95_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4699_ _1759_ _1762_ _1758_ VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_8 _2102_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2952_ net105 _0313_ _0314_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2883_ _0252_ _0221_ _0240_ _0231_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_20_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4622_ _1698_ net527 VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_12_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4553_ _1645_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_25_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3504_ _0799_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_4
XFILLER_0_114_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4484_ _1587_ _1588_ _1589_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__and3_1
X_3435_ _0733_ _0736_ _0444_ _0718_ VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_110_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3366_ sm1.s1.t1.A_wire\[3\] sm1.s1.t1.A_wire\[4\] _0668_ VGND VGND VPWR VPWR _0676_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_0_57_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5105_ _2051_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_3297_ _0522_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_90_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5036_ _2015_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput101 data8[4] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_8_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3220_ _0546_ _0519_ _0527_ _0537_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a221o_1
X_3151_ _0263_ _0459_ _0463_ _0275_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3082_ _0366_ _0396_ _0411_ _0353_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_124_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3984_ _1175_ _1177_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_33_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2935_ sm1.s2.t2.A_wire\[3\] VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__buf_2
XFILLER_0_84_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2866_ _0238_ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_115_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4605_ _1687_ _1688_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2797_ _2172_ _0153_ _0163_ _0079_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o211a_2
XTAP_TAPCELL_ROW_79_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4536_ _1264_ _1602_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4467_ _1548_ _1550_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__nand2_2
X_4398_ net231 net314 VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__nand2_2
X_3418_ _0719_ sm1.s1.t1.A_wire\[10\] _0707_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nor3_2
X_3349_ net105 _0649_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_5_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5019_ net439 net454 VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2720_ _0089_ _0094_ _0111_ _0084_ _0088_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_30_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2651_ _2278_ _2301_ _2344_ _2345_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__a211o_1
XFILLER_0_54_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2582_ _2229_ _2285_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__and2_1
Xoutput416 net416 VGND VGND VPWR VPWR partial_sum14_2[6] sky130_fd_sc_hd__buf_1
Xoutput405 net405 VGND VGND VPWR VPWR partial_sum14_1[9] sky130_fd_sc_hd__buf_1
XFILLER_0_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4321_ _1459_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_2
Xoutput449 net449 VGND VGND VPWR VPWR partial_sum15_1[0] sky130_fd_sc_hd__buf_1
Xoutput438 net438 VGND VGND VPWR VPWR partial_sum15[13] sky130_fd_sc_hd__buf_1
Xoutput427 net427 VGND VGND VPWR VPWR partial_sum14_3[3] sky130_fd_sc_hd__buf_1
XFILLER_0_22_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4252_ net562 _1404_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3203_ _0525_ _0528_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__nor3_4
XFILLER_0_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4183_ _1328_ _1347_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3134_ _0473_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_2
X_3065_ _0410_ _0412_ _0414_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_38_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3967_ net310 net228 VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2918_ _0261_ _0240_ _0276_ _0263_ _2187_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__a221o_1
X_3898_ _1118_ _1103_ _1121_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2849_ _0216_ _0218_ _0221_ _0217_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a221o_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4519_ _1617_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
XFILLER_0_68_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_121_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4870_ _1882_ _1883_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3821_ _1066_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_117_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3752_ _0995_ _0996_ _1005_ _1004_ _0997_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__o311a_1
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3683_ _2108_ _2094_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__and3_2
XFILLER_0_125_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2703_ _2102_ _0071_ _0074_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and3_2
XFILLER_0_54_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2634_ _2331_ VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_40_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2565_ _2270_ _2263_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__nand2_1
Xoutput202 net202 VGND VGND VPWR VPWR final_sum8[2] sky130_fd_sc_hd__buf_1
Xoutput224 net224 VGND VGND VPWR VPWR out1_2[4] sky130_fd_sc_hd__buf_1
Xoutput213 net213 VGND VGND VPWR VPWR out1[3] sky130_fd_sc_hd__buf_1
Xoutput235 net235 VGND VGND VPWR VPWR out1_3[5] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_132_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4304_ net565 _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__xnor2_4
Xoutput246 net246 VGND VGND VPWR VPWR out1_4[6] sky130_fd_sc_hd__buf_1
Xoutput257 net257 VGND VGND VPWR VPWR out1_5[7] sky130_fd_sc_hd__buf_1
Xoutput268 net268 VGND VGND VPWR VPWR out1_6[8] sky130_fd_sc_hd__buf_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2496_ sm2.s1.t1.A_wire\[3\] VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput279 net279 VGND VGND VPWR VPWR out1_7[9] sky130_fd_sc_hd__buf_1
X_4235_ net572 _1377_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__and2_1
X_4166_ _0108_ net372 VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3117_ _0213_ _0224_ net8 VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4097_ _1228_ net107 VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__and2b_1
X_3048_ _2149_ _0395_ _0388_ _0300_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_77_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4999_ _1990_ _1991_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__or2b_1
XFILLER_0_18_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4020_ _1217_ _1205_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_48_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4922_ _1929_ _1930_ _1931_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4853_ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_82_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4784_ _2118_ _1794_ _1796_ _2116_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__a22o_1
X_3804_ _1049_ _1046_ _1051_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__o21bai_4
X_3735_ _0992_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand2_2
XFILLER_0_70_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3666_ net28 net30 VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and2b_1
X_3597_ _0764_ _0738_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2617_ _2213_ _2211_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2548_ _2229_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__and2_1
X_2479_ _2186_ _2114_ _2130_ _2168_ _2193_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__a221o_1
X_4218_ net572 _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__xnor2_2
X_5198_ clknet_3_6__leaf_clk _0034_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_4149_ _1319_ _1320_ VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__xor2_4
XFILLER_0_97_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload0 clknet_3_0__leaf_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_0_21_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3520_ _0813_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3451_ net11 _0738_ net105 VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2402_ _2082_ _2122_ _2103_ net27 VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__or4b_2
XFILLER_0_110_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3382_ _0673_ _0656_ _0666_ _0677_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o211a_1
X_5121_ _0102_ net100 _2056_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__mux2_1
XFILLER_0_137_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5052_ _0326_ net67 _2023_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4003_ net299 net218 _1190_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a21o_2
XFILLER_0_46_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_127_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4905_ _1917_ _1918_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__xnor2_2
X_4836_ _1863_ _1864_ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__xor2_4
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4767_ _1801_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_90_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3718_ _2184_ _0951_ _0946_ _2195_ _0976_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_95_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4698_ _1764_ VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__inv_2
XFILLER_0_30_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3649_ _0921_ _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_9 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2951_ net20 _0302_ _0300_ net16 VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nand4b_1
XFILLER_0_84_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2882_ _0215_ _0233_ _0236_ _2122_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_20_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4621_ _1701_ _1703_ VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__xnor2_4
XFILLER_0_72_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4552_ _1643_ _1644_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__and2_2
XFILLER_0_25_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3503_ _0792_ _0797_ _0798_ _0777_ _0780_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__o32a_1
X_4483_ _1558_ _1568_ _1567_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3434_ _0685_ _0728_ _0724_ _0698_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3365_ sm1.s1.t1.A_wire\[3\] sm1.s1.t1.A_wire\[4\] sm1.s1.t1.A_wire\[5\] VGND VGND
+ VPWR VPWR _0675_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_129_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5104_ _0537_ net92 _2045_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__mux2_1
X_3296_ _0597_ _0590_ _0600_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_90_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5035_ _0769_ net59 _2012_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4819_ _1843_ _1848_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput102 data8[5] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_8_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_22_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ _0280_ _0455_ _0464_ _0270_ _0461_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a221o_1
X_3081_ _0352_ _0408_ _0427_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a211o_1
XFILLER_0_27_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3983_ _1176_ net489 VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2934_ _0298_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__inv_2
XFILLER_0_57_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2865_ _0228_ _0229_ _0234_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__or4_1
X_4604_ net239 net322 VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2796_ _0105_ _0162_ _0177_ _0085_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__a22o_1
X_4535_ net388 net402 VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_135_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4466_ net139 net152 VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4397_ _1515_ VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__inv_2
X_3417_ sm1.s1.t1.A_wire\[9\] _0707_ _0718_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3348_ sm1.s1.t1.A_wire\[3\] _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_5_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ _0501_ _0497_ _0584_ _0508_ _2101_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o311a_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5018_ net439 net454 VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2650_ _2279_ _2300_ _2313_ _2272_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2581_ _2279_ _2269_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput417 net417 VGND VGND VPWR VPWR partial_sum14_2[7] sky130_fd_sc_hd__buf_1
Xoutput406 net406 VGND VGND VPWR VPWR partial_sum14_2[0] sky130_fd_sc_hd__buf_1
X_4320_ net566 _1457_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__and2_1
Xoutput439 net439 VGND VGND VPWR VPWR partial_sum15[14] sky130_fd_sc_hd__buf_1
Xoutput428 net428 VGND VGND VPWR VPWR partial_sum14_3[4] sky130_fd_sc_hd__buf_1
X_4251_ net562 _1404_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3202_ _0522_ _0519_ _0532_ _0495_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4182_ _1328_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3133_ _0217_ _0469_ _0470_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__o22a_1
X_3064_ _0337_ _0405_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_18_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_35_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3966_ net310 net228 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_137_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2917_ _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__nor2_4
XFILLER_0_115_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3897_ _1118_ _1103_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2848_ _2084_ sm1.s1.t2.A_wire\[3\] _0211_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__and3_1
X_2779_ _0075_ _0064_ _0145_ _0146_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o31a_1
XFILLER_0_103_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_241 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4518_ _1615_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__and2_2
XFILLER_0_79_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_44_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4449_ _0776_ _0852_ _1517_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_68_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_53_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3820_ _1064_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__and2_1
X_3751_ _1007_ VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2702_ _0084_ _0094_ _0095_ _0085_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3682_ _2097_ _2129_ net28 VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__mux2_1
XFILLER_0_125_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2633_ _2325_ _2327_ _2330_ _2227_ _2086_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__o32a_1
X_2564_ sm2.s1.t1.A_wire\[9\] VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput225 net225 VGND VGND VPWR VPWR out1_2[5] sky130_fd_sc_hd__buf_1
Xoutput214 net214 VGND VGND VPWR VPWR out1[4] sky130_fd_sc_hd__buf_1
Xoutput203 net203 VGND VGND VPWR VPWR final_sum8[3] sky130_fd_sc_hd__buf_1
XFILLER_0_23_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4303_ _1315_ _0134_ _1317_ _0132_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput236 net236 VGND VGND VPWR VPWR out1_3[6] sky130_fd_sc_hd__buf_1
Xoutput247 net247 VGND VGND VPWR VPWR out1_4[7] sky130_fd_sc_hd__buf_1
Xoutput258 net258 VGND VGND VPWR VPWR out1_5[8] sky130_fd_sc_hd__buf_1
X_2495_ _2207_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__inv_2
Xoutput269 net269 VGND VGND VPWR VPWR out1_6[9] sky130_fd_sc_hd__buf_1
X_4234_ net572 _1377_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4165_ _1319_ _1320_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a21o_2
X_3116_ _0457_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_87_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4096_ _1241_ _1246_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__xor2_4
X_3047_ _0399_ VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__inv_2
XFILLER_0_77_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4998_ net435 net450 VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3949_ net501 _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_107_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4921_ _1486_ net417 VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__and2b_1
X_4852_ _1876_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3803_ _1012_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4783_ _1801_ _1820_ _1821_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3734_ _0987_ _0991_ _0989_ _0990_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nand4_2
XFILLER_0_15_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3665_ net30 net28 VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__and2b_1
XFILLER_0_70_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2616_ _2249_ _2301_ _2313_ _2239_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3596_ _0809_ _0844_ _0849_ _0801_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2547_ sm2.s1.t1.A_wire\[7\] _2246_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__xor2_4
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2478_ _2188_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__buf_4
X_4217_ _1315_ _0105_ _1317_ _0102_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5197_ clknet_3_6__leaf_clk _0033_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
X_4148_ net283 net371 VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__xor2_4
XFILLER_0_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4079_ _1146_ _1159_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload1 clknet_3_1__leaf_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3450_ _0738_ net13 net15 VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__or3b_1
XFILLER_0_122_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2401_ _2121_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__clkbuf_8
X_3381_ _0688_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__and2_2
X_5120_ _2059_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5051_ _2011_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4002_ _1208_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4904_ _1914_ _1916_ _1913_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_47_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4835_ net354 net268 _1853_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_117_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4766_ _1806_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3717_ _2168_ _0957_ _0978_ VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__o21a_2
XFILLER_0_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4697_ _1754_ _1763_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3648_ _0672_ _0887_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3579_ _0803_ _0832_ _0849_ _0782_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5249_ net162 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_59_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2950_ _0300_ _0302_ net20 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__or3b_1
XFILLER_0_96_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2881_ sm1.s1.t2.A_wire\[7\] VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4620_ _1672_ _1676_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__a21o_2
XFILLER_0_115_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4551_ _1633_ _1615_ _1642_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__nand3_1
XFILLER_0_89_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3502_ _0745_ _0787_ _0760_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__and3_1
X_4482_ _1585_ _1586_ _1580_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3433_ _0733_ _0735_ _2204_ _0719_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_110_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5103_ _2050_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_3364_ _0673_ _0656_ _0659_ _0666_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_129_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3295_ _0614_ VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_90_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5034_ _2014_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4818_ _1052_ _1053_ net181 VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__and3_1
XFILLER_0_63_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4749_ _1790_ _1787_ _1791_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput103 data8[6] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3080_ _0347_ _0413_ _0397_ _0367_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3982_ net490 _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__xor2_2
XFILLER_0_43_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2933_ _2204_ _0280_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_127_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_99_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2864_ _0231_ _0219_ _0220_ _0236_ sm1.s1.t2.A_wire\[3\] VGND VGND VPWR VPWR _0237_
+ sky130_fd_sc_hd__a32o_1
XFILLER_0_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2795_ _0172_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__inv_2
X_4603_ net239 net322 VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4534_ _1609_ _1629_ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_135_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4465_ _1546_ _1573_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__xnor2_4
X_4396_ _1510_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__xor2_2
X_3416_ _0694_ _0715_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a21o_1
X_3347_ sm1.s1.t1.A_wire\[4\] VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_5_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ _0597_ _0591_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__and3_2
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5017_ _2001_ _2004_ _2005_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_101_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput407 net407 VGND VGND VPWR VPWR partial_sum14_2[10] sky130_fd_sc_hd__buf_1
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _2279_ _2240_ _2272_ _2234_ _2233_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__a221o_1
Xoutput418 net418 VGND VGND VPWR VPWR partial_sum14_2[8] sky130_fd_sc_hd__buf_1
Xoutput429 net429 VGND VGND VPWR VPWR partial_sum14_3[5] sky130_fd_sc_hd__buf_1
X_4250_ _1311_ _0554_ _1313_ _0552_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a22o_1
X_3201_ _0529_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__or2_1
X_4181_ _1329_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__inv_2
X_3132_ _0239_ _0455_ _0461_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a211o_1
XFILLER_0_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3063_ _2187_ _0413_ _0299_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3965_ _1166_ _1168_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3896_ _1119_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__nand2_1
X_2916_ sm1.s1.t2.A_wire\[10\] _0273_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2847_ _0219_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2778_ _0080_ _0157_ _0155_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__and3_2
X_4517_ _1610_ _1590_ _1614_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4448_ _0776_ _0852_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__or2_1
X_4379_ _1502_ _1504_ VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3750_ _1004_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_15_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2701_ _2094_ net40 _0074_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__and3_2
XFILLER_0_82_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3681_ _2108_ _2084_ _0937_ _0941_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2632_ _2230_ _2328_ _2329_ _2237_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2563_ sm2.s1.t1.A_wire\[9\] _2263_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput226 net226 VGND VGND VPWR VPWR out1_2[6] sky130_fd_sc_hd__buf_1
Xoutput204 net204 VGND VGND VPWR VPWR final_sum8[4] sky130_fd_sc_hd__buf_1
Xoutput215 net215 VGND VGND VPWR VPWR out1[5] sky130_fd_sc_hd__buf_1
XFILLER_0_23_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4302_ _1444_ _1447_ VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__xnor2_4
XFILLER_0_2_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput237 net237 VGND VGND VPWR VPWR out1_3[7] sky130_fd_sc_hd__buf_1
Xoutput248 net248 VGND VGND VPWR VPWR out1_4[8] sky130_fd_sc_hd__buf_1
Xoutput259 net259 VGND VGND VPWR VPWR out1_5[9] sky130_fd_sc_hd__buf_1
X_2494_ _2193_ _2205_ _2182_ _2206_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__a211o_2
XFILLER_0_120_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4233_ _1390_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4164_ net283 net371 VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4095_ _1282_ VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__inv_2
X_3115_ _0208_ _0453_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_87_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3046_ _0319_ _0396_ _0397_ _0324_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4997_ net435 net450 VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3948_ _0255_ _1087_ _1089_ _0252_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3879_ _1103_ _1104_ _1105_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_247 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_107_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4920_ _1929_ _1930_ VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__xor2_1
XFILLER_0_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4851_ _2207_ _0980_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3802_ _2296_ _2255_ _1028_ _2257_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_129_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4782_ _1806_ _1807_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3733_ _0987_ _0989_ _0990_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__a31o_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3664_ _0718_ _0904_ _0934_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__o21a_1
X_2615_ _2227_ _2309_ _2307_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3595_ _0877_ VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_2
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2546_ _2234_ _2239_ _2242_ _2249_ _2233_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__a221o_1
X_2477_ _2147_ _2180_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__nor2_1
X_5196_ clknet_3_6__leaf_clk _0032_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_4216_ _1374_ _1376_ VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__xnor2_4
X_4147_ _1304_ _1306_ _1305_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__a21o_2
X_4078_ net129 net116 VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3029_ _0374_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_248 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload2 clknet_3_2__leaf_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_4
XFILLER_0_104_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2400_ _2120_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3380_ _0683_ _0675_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5050_ _2022_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_4001_ net300 net219 VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4903_ net428 net414 VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__xor2_1
XFILLER_0_62_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_80_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4834_ _1861_ _1862_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__nand2_2
XFILLER_0_28_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4765_ _2092_ _1794_ _1796_ _2105_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_16_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3716_ _2184_ _0946_ _0976_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4696_ _1291_ net395 VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__xnor2_2
X_3647_ _0719_ _0707_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3578_ _0863_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_113_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2529_ _2236_ _2238_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__and2_2
XFILLER_0_11_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5248_ net158 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__clkbuf_1
X_5179_ clknet_3_0__leaf_clk _0015_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_119_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_128_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_137_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_126_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2880_ _0251_ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_84_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4550_ _1633_ _1615_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3501_ _0793_ _0759_ _0756_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__a22o_1
X_4481_ _1580_ _1585_ _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__or3_1
XFILLER_0_52_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3432_ _0685_ _0724_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3363_ _0672_ _0649_ net2 net3 VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor4_2
X_5102_ _0522_ net91 _2045_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_129_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _0607_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__nor3b_2
XTAP_TAPCELL_ROW_90_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5033_ _0757_ net58 _2012_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_56_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4817_ _1843_ _1848_ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__xor2_2
XFILLER_0_118_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4748_ net163 net176 VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__nand2_1
X_4679_ _1748_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput104 data8[7] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_128_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_22 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3981_ _0709_ _1094_ _1096_ _0703_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2932_ _0276_ _0289_ _0285_ _0248_ _0294_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__a221o_1
XFILLER_0_57_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ _2121_ _0224_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__nor3_2
X_2794_ _0109_ _0154_ _0156_ _0111_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__a22o_1
X_4602_ _0742_ _0801_ _1532_ _0803_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__a22oi_2
X_4533_ net141 net154 VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_135_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4464_ net522 _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__xor2_4
XFILLER_0_110_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4395_ _1512_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3415_ _0718_ _0662_ _0687_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a22o_1
X_3346_ _2101_ _0649_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and3_2
X_3277_ _2093_ _0504_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and2_1
X_5016_ net438 net453 VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_101_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput408 net408 VGND VGND VPWR VPWR partial_sum14_2[11] sky130_fd_sc_hd__buf_1
XFILLER_0_22_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput419 net419 VGND VGND VPWR VPWR partial_sum14_2[9] sky130_fd_sc_hd__buf_1
XFILLER_0_1_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3200_ _2102_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_2
X_4180_ net559 _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__xor2_2
X_3131_ _0247_ _0454_ _0459_ _0218_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3062_ _2149_ _0329_ _0401_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_38_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3964_ net501 _1165_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_18_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3895_ _0269_ _0477_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__nand2_1
X_2915_ _0280_ _0273_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2846_ _0212_ _0214_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_72_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2777_ _0094_ _0156_ _0160_ _0082_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_79_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4516_ _1610_ _1590_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4447_ _1533_ net509 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__and2b_2
X_4378_ _1497_ _1499_ _1503_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__a21o_1
X_3329_ _0562_ _0619_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2700_ _0091_ _0093_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__and2_2
XFILLER_0_82_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3680_ _2116_ _0942_ _0946_ _2092_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2631_ _2309_ _2307_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2562_ _2234_ _2255_ _2265_ _2242_ _2233_ VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__a221o_1
Xoutput205 net205 VGND VGND VPWR VPWR final_sum8[5] sky130_fd_sc_hd__buf_1
Xoutput216 net216 VGND VGND VPWR VPWR out1[6] sky130_fd_sc_hd__buf_1
XFILLER_0_23_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4301_ _1445_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput227 net227 VGND VGND VPWR VPWR out1_2[7] sky130_fd_sc_hd__buf_1
Xoutput238 net238 VGND VGND VPWR VPWR out1_3[8] sky130_fd_sc_hd__buf_1
Xoutput249 net249 VGND VGND VPWR VPWR out1_4[9] sky130_fd_sc_hd__buf_1
X_2493_ _2109_ _2183_ _2103_ _2202_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__o211a_1
X_4232_ _1386_ _1389_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__xnor2_4
X_4163_ _1318_ net569 VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__and2b_2
X_4094_ _1279_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__xnor2_4
X_3114_ _0218_ _0454_ _0455_ _0217_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__a22o_1
X_3045_ _2110_ _0299_ _0301_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4996_ _1988_ _1989_ VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__xor2_1
XFILLER_0_105_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3947_ _1163_ _1164_ VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__nor2_4
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3878_ _1103_ _1104_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__and3_1
XFILLER_0_33_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2829_ _0203_ _0204_ _0205_ _0123_ _2177_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__o32a_1
XFILLER_0_116_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_100_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4850_ _2207_ _0980_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3801_ _1007_ _1044_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nor2_1
X_4781_ _1806_ _1807_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3732_ net254 net339 VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3663_ _0724_ _0910_ _0898_ _0728_ _0931_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a221o_1
X_2614_ _2299_ _2305_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__and2b_2
XFILLER_0_70_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_360 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3594_ _2177_ _0793_ _0874_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__o22a_1
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2545_ _2253_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__buf_2
X_2476_ _2191_ VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__buf_2
XFILLER_0_76_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4215_ _1355_ _1356_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__a21o_2
X_5195_ clknet_3_2__leaf_clk _0031_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
X_4146_ _1315_ _1317_ _2357_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__o21ai_4
X_4077_ _1267_ _1268_ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__xor2_2
XFILLER_0_78_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3028_ _0366_ _0342_ _0383_ VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__o21a_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4979_ net445 net460 VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload3 clknet_3_3__leaf_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__bufinv_16
XFILLER_0_18_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4000_ net300 net219 VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__or2_1
XFILLER_0_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4902_ _1915_ _1916_ VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4833_ net355 net269 VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4764_ _1802_ _1805_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_43_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3715_ _2170_ _0951_ _0945_ _2186_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4695_ _1759_ _1762_ VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__xor2_4
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3646_ _0683_ _0904_ _0918_ _0920_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__o22a_2
X_3577_ _0859_ _0861_ _0862_ _0769_ _2085_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__o32a_1
XFILLER_0_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2528_ sm2.s1.t1.A_wire\[3\] sm2.s1.t1.A_wire\[4\] _2237_ VGND VGND VPWR VPWR _2238_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5247_ net150 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__buf_1
X_2459_ _2088_ _2126_ _2166_ _2175_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__o22a_1
X_5178_ clknet_3_1__leaf_clk _0014_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
X_4129_ net281 net369 VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__and2_2
XFILLER_0_78_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_126_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3500_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__and2_2
XFILLER_0_107_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4480_ _1581_ _1564_ _1584_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3431_ _0718_ _0681_ _0715_ _0698_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a22o_1
X_3362_ net5 VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_4
X_5101_ _2049_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3293_ _2187_ _0495_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_90_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5032_ _2013_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4816_ _1054_ net181 VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4747_ net163 net176 VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4678_ _1734_ _1736_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3629_ _0658_ _0896_ _0897_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput105 en VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3980_ _1190_ _1191_ VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__nor2_4
XFILLER_0_43_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2931_ _0296_ VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4601_ net514 _1667_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__and2_1
X_2862_ _0210_ net8 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__nor2_1
X_2793_ _0175_ VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_115_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4532_ _1620_ _1628_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__xor2_4
XFILLER_0_130_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4463_ _0305_ _0324_ _1539_ _0319_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a22o_2
XFILLER_0_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3414_ sm1.s1.t1.A_wire\[9\] VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4394_ net383 net397 VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3345_ _0653_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__xor2_2
X_3276_ _0501_ _0497_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__or2_4
XFILLER_0_84_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5015_ _2002_ _2004_ VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput409 net409 VGND VGND VPWR VPWR partial_sum14_2[12] sky130_fd_sc_hd__buf_1
X_3130_ _0233_ _0463_ _0464_ _0231_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3061_ _0324_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3963_ _1175_ _1177_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_18_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_303 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3894_ _0269_ _0477_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__or2_1
X_2914_ _0270_ _0243_ _0275_ _0257_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a221o_1
X_2845_ net105 net6 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__and2_2
XFILLER_0_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2776_ _0080_ _0157_ _0153_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__and3_2
X_4515_ net512 _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4446_ _1557_ VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__inv_2
XFILLER_0_41_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4377_ net186 net199 VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__and2_1
X_3328_ _0508_ _0567_ _0641_ _2177_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_13_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3259_ _2087_ _0501_ _0495_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_1_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_22_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ _2084_ _2316_ _2317_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__and3_2
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput217 net217 VGND VGND VPWR VPWR out1[7] sky130_fd_sc_hd__buf_1
Xoutput206 net206 VGND VGND VPWR VPWR final_sum8[6] sky130_fd_sc_hd__buf_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2561_ _2267_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
X_2492_ _2186_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__inv_2
X_4300_ net280 net368 VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__or2_1
Xoutput228 net228 VGND VGND VPWR VPWR out1_2[8] sky130_fd_sc_hd__buf_1
Xoutput239 net239 VGND VGND VPWR VPWR out1_3[9] sky130_fd_sc_hd__buf_1
XFILLER_0_23_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4231_ _1387_ _1368_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__o21a_2
XFILLER_0_10_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4162_ _1331_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__inv_2
X_4093_ net131 net118 _1280_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o21a_2
X_3113_ _0219_ _0235_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__and2_2
X_3044_ _2131_ _0310_ _0395_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and3_2
XFILLER_0_65_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4995_ net448 net463 VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3946_ _1160_ _1161_ _1162_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__nor3_1
XFILLER_0_116_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3877_ _0218_ _1087_ _1089_ _0217_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2828_ _0126_ _0177_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_98_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2759_ _0144_ _0071_ _0064_ _0075_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_30_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4429_ _1520_ _1522_ _1521_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4780_ _1810_ _1812_ _1818_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21o_1
X_3800_ _1048_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_2
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3731_ _0988_ _0982_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3662_ _0719_ _0904_ _0931_ _0933_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__o22a_2
XFILLER_0_42_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3593_ _0816_ _0834_ _0849_ _0796_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a221o_1
X_2613_ _2312_ VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__buf_2
XFILLER_0_70_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2544_ _2245_ _2250_ _2251_ _2252_ _2227_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__o32a_1
XFILLER_0_23_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2475_ _2177_ _2140_ _2179_ _2190_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__o22a_1
X_4214_ _0114_ _0187_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5194_ clknet_3_2__leaf_clk _0030_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
X_4145_ _1316_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4076_ net128 _1159_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3027_ _0334_ _0375_ _0380_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__a211o_1
XFILLER_0_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4978_ _1973_ _1975_ VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__xor2_1
Xclkload4 clknet_3_4__leaf_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_2
X_3929_ net297 net216 VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput570 net570 VGND VGND VPWR VPWR sum_out8[4] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_70_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4901_ _1910_ _1912_ _1908_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__o21a_1
XFILLER_0_87_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4832_ net355 net269 VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4763_ _1803_ _1789_ _1804_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_28_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3714_ _2195_ _0975_ _0949_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a21o_1
X_4694_ _1739_ _1760_ _1761_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__a21o_2
XFILLER_0_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_95_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3645_ _0699_ _0898_ _0896_ _0695_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__a221o_1
X_3576_ _0796_ _0834_ _0849_ _0771_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2527_ sm2.s1.t1.A_wire\[5\] VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__buf_2
X_2458_ _2140_ _2130_ _2170_ _2100_ _2174_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__a221o_1
X_5246_ net149 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2389_ _2083_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__clkbuf_4
X_5177_ clknet_3_4__leaf_clk _0013_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
X_4128_ _1303_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
X_4059_ _1251_ _1252_ _1253_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_104_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3430_ _0669_ _0661_ _0723_ _2204_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__o31a_1
X_3361_ _0668_ _0660_ _0661_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a31o_1
X_5100_ _0516_ net90 _2045_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5031_ _0737_ net57 _2012_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__mux2_1
X_3292_ _0539_ _0594_ _0609_ _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_87_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4815_ _1845_ _1847_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__xor2_4
XFILLER_0_63_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4746_ _1788_ _1789_ VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__xnor2_4
XFILLER_0_16_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4677_ _1282_ _1733_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3628_ _0677_ _0889_ _0898_ _0659_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__a221o_1
XFILLER_0_43_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3559_ _0749_ _0831_ _0840_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__and3_2
XFILLER_0_9_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_136_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_90 net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_128_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2930_ _0293_ _0294_ _0295_ _0270_ _2202_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__o32a_1
XFILLER_0_84_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4600_ _1684_ VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__inv_2
XFILLER_0_38_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2861_ _2094_ net6 _0215_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__and4_1
X_2792_ _0170_ _0173_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_68_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4531_ net524 _1627_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__xor2_2
XFILLER_0_53_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4462_ _1570_ _1571_ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__xor2_4
XFILLER_0_40_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3413_ sm1.s1.t1.A_wire\[10\] VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__buf_2
XFILLER_0_7_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4393_ net383 net397 VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3344_ net3 _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xor2_4
X_3275_ _0596_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__inv_2
XFILLER_0_84_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5014_ _1997_ _1999_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_77_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_86_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4729_ _1777_ VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_95_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_67_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_137_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3060_ _2110_ _0402_ _0401_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_38_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3962_ net489 _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_18_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3893_ net306 net224 VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__nand2_1
X_2913_ _0280_ _0219_ _0220_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2844_ sm1.s1.t2.A_wire\[3\] _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xor2_4
XFILLER_0_115_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4514_ _0742_ _0782_ _1532_ _0780_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__a22o_1
X_2775_ _0159_ VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4445_ _1555_ _1556_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4376_ _1500_ _1501_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__nand2_1
X_3327_ _0597_ _0591_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__and2_1
X_3258_ _0581_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_1_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3189_ _0515_ _0513_ _0517_ _0520_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__a31o_2
XFILLER_0_138_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput207 net207 VGND VGND VPWR VPWR final_sum8[7] sky130_fd_sc_hd__buf_1
X_2560_ _2260_ _2262_ _2266_ _2252_ _2247_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__o32a_1
X_2491_ _2199_ _2203_ _2204_ _2168_ VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__o2bb2a_2
Xoutput229 net229 VGND VGND VPWR VPWR out1_2[9] sky130_fd_sc_hd__buf_1
Xoutput218 net218 VGND VGND VPWR VPWR out1[8] sky130_fd_sc_hd__buf_1
XFILLER_0_50_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4230_ net560 _1364_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__nand2_1
X_4161_ _1321_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4092_ net131 net118 _1272_ _1274_ _1276_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__a221o_1
X_3112_ _0210_ net8 _0219_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__and3_2
X_3043_ _2122_ _0388_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nor3_4
XFILLER_0_81_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4994_ _1985_ _1986_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3945_ _1160_ _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__o21a_1
XFILLER_0_46_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3876_ _1099_ _1102_ _1100_ _1101_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__or4_2
XFILLER_0_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2827_ _0147_ _0131_ _0155_ _2193_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2758_ net37 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__inv_2
XFILLER_0_131_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2689_ _0071_ _0074_ _0081_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_111_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4428_ _0305_ _1539_ _0299_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__o21a_2
XFILLER_0_111_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4359_ _1483_ _1485_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_96_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_107_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_118_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_131_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_86_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3730_ _2244_ _0988_ _2322_ _0984_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3661_ _0724_ _0898_ _0896_ _0718_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a221o_1
X_3592_ _0801_ _0844_ _0847_ _0803_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a22o_1
X_2612_ _2304_ _2308_ _2310_ _2311_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__or4b_1
XFILLER_0_113_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2543_ _2144_ _2210_ _2225_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_23_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2474_ _2155_ _2130_ _2181_ _2185_ _2189_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_76_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4213_ _1372_ _1373_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nand2_2
XFILLER_0_76_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5193_ clknet_3_2__leaf_clk _0029_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
X_4144_ net39 _0071_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4075_ _1265_ _1263_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_50_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3026_ _0381_ _0374_ _0342_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_116_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4977_ _1971_ _1972_ _1974_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload5 clknet_3_6__leaf_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__clkinvlp_4
X_3928_ _1136_ _1138_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a21o_2
XFILLER_0_6_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3859_ _1087_ _1089_ _0208_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_33_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput571 net571 VGND VGND VPWR VPWR sum_out8[5] sky130_fd_sc_hd__buf_1
Xoutput560 net560 VGND VGND VPWR VPWR sum_out7[6] sky130_fd_sc_hd__buf_1
XFILLER_0_112_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_70_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4900_ _1913_ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4831_ _1850_ _1860_ VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__xor2_2
XFILLER_0_28_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4762_ net349 net263 VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__and2_1
X_3713_ _0939_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__inv_2
X_4693_ _1742_ _1746_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3644_ _0707_ _0708_ _0889_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3575_ _0782_ _0844_ _0847_ _0780_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__a221o_1
XFILLER_0_113_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2526_ sm2.s1.t1.A_wire\[3\] sm2.s1.t1.A_wire\[4\] sm2.s1.t1.A_wire\[5\] VGND VGND
+ VPWR VPWR _2236_ sky130_fd_sc_hd__or3_1
X_2457_ _2128_ _2161_ _2171_ _2173_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__a211o_1
X_5245_ net145 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__buf_1
X_2388_ _2108_ net27 _2082_ net28 VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__or4_2
X_5176_ clknet_3_4__leaf_clk _0012_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_4127_ _1299_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__xor2_4
XFILLER_0_78_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4058_ _1251_ _1252_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3009_ _0366_ _0359_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_104_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput390 net390 VGND VGND VPWR VPWR partial_sum14[8] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_58_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_126_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_106_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_115_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3360_ net105 sm1.s1.t1.A_wire\[3\] _0669_ _0665_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__and4_1
XFILLER_0_57_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5030_ _2011_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__clkbuf_4
X_3291_ _0516_ _0597_ _0591_ _0600_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4814_ net549 _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4745_ _1781_ _1783_ _1782_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4676_ net380 net394 VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_133_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3627_ _0902_ _0904_ _0650_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a21boi_1
X_3558_ _0771_ _0838_ _0844_ _0758_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a221o_1
XFILLER_0_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2509_ _2213_ net22 VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__nor2_1
X_3489_ _0745_ _0780_ _0760_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__and3_1
X_5159_ _2079_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_91 net557 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_80 net349 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2860_ _0230_ _0232_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__and2_2
XFILLER_0_57_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2791_ _0092_ _0160_ _0162_ _0094_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__a22o_1
XFILLER_0_127_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4530_ _0305_ _0347_ _1539_ _0344_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4461_ net244 net328 VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3412_ _2087_ _0683_ _0714_ _0717_ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__o22a_2
X_4392_ _1507_ _1511_ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__xor2_2
XFILLER_0_0_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3343_ net2 net1 VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__or2b_2
X_3274_ _0516_ _0592_ _0594_ _0517_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_84_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5013_ _1764_ net452 VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__and2b_1
XFILLER_0_108_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _0319_ _0342_ _0343_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__o22a_1
XFILLER_0_16_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4728_ _1775_ _1776_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4659_ _1282_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__xor2_2
XFILLER_0_114_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3961_ _0699_ _1094_ _1096_ _0695_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_57_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2912_ sm1.s1.t2.A_wire\[10\] VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_46_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3892_ _1117_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__inv_2
XFILLER_0_45_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2843_ sm1.s1.t2.A_wire\[4\] VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__buf_4
X_2774_ _0082_ _0154_ _0156_ _0085_ _0158_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4513_ _1611_ _1612_ VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__xor2_4
XFILLER_0_53_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4444_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4375_ net187 net200 VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__or2_1
X_3326_ _2177_ _0552_ _0638_ _0640_ VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__o22a_2
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3257_ _0571_ _0543_ _0575_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__o22a_1
X_3188_ sm2.s2.t1.A_wire\[3\] _0518_ _0519_ _0516_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_1_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_131_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput208 net208 VGND VGND VPWR VPWR final_sum8[8] sky130_fd_sc_hd__buf_1
XFILLER_0_50_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput219 net219 VGND VGND VPWR VPWR out1[9] sky130_fd_sc_hd__buf_1
X_2490_ _2202_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_49_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4160_ _1328_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_65_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3111_ _2101_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and2_1
X_4091_ _1228_ net107 VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__xnor2_4
X_3042_ _0310_ _0390_ _0393_ _0308_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a2111o_4
XFILLER_0_77_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4993_ _1684_ net462 VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3944_ net309 net227 VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3875_ _1099_ _1100_ _1101_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__o31ai_4
X_2826_ _0132_ _0179_ _0166_ _0134_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2757_ _0132_ _0100_ _0140_ _0143_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__o22a_4
X_2688_ _0074_ _0081_ _0071_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and3b_2
X_4427_ _1538_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__clkbuf_4
X_4358_ _1390_ net207 VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__or2b_1
X_3309_ _0623_ _0625_ _0626_ _0522_ _2086_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__o32a_1
X_4289_ net270 _0648_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_107_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3660_ _0921_ _0902_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__nor2_1
X_3591_ _0809_ _0838_ _0839_ _0807_ _2193_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_97_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2611_ _2149_ _2291_ _2299_ _2239_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__or4b_1
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2542_ _2247_ _2228_ _2240_ _2237_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2473_ _2186_ _2104_ _2114_ _2168_ _2188_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__a221o_1
X_4212_ net286 net374 VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nand2_1
X_5192_ clknet_3_2__leaf_clk _0028_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_4143_ net39 _0071_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__nor2_4
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4074_ net127 net114 VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__and2_1
X_3025_ _0320_ _0317_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4976_ _1578_ _1919_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3927_ net487 _1137_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload6 clknet_3_7__leaf_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinv_1
XFILLER_0_33_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3858_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__clkbuf_4
X_2809_ _0123_ _0154_ _0160_ _0117_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3789_ _1037_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__or2_2
Xoutput572 net572 VGND VGND VPWR VPWR sum_out8[6] sky130_fd_sc_hd__buf_1
Xoutput561 net561 VGND VGND VPWR VPWR sum_out7[7] sky130_fd_sc_hd__buf_1
Xoutput550 net550 VGND VGND VPWR VPWR sum_out6[8] sky130_fd_sc_hd__buf_1
XFILLER_0_1_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4830_ _1060_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__xor2_2
XFILLER_0_28_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4761_ net349 net263 VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3712_ _0974_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
X_4692_ _1742_ _1746_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3643_ _0703_ _0890_ _0910_ _0690_ _0909_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a221o_1
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3574_ _2131_ _0764_ _0793_ _0831_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_588 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2525_ _2233_ _2234_ _2208_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__o21a_1
X_2456_ _2168_ _2104_ _2114_ _2155_ _2172_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__a221o_1
X_5244_ net137 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5175_ clknet_3_4__leaf_clk _0011_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
X_2387_ net30 VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__clkbuf_4
X_4126_ _1300_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__nand2_2
X_4057_ net124 net111 VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__xor2_1
X_3008_ sm1.s2.t2.A_wire\[9\] VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_104_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4959_ net441 net456 VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_22_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_115_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput380 net380 VGND VGND VPWR VPWR partial_sum14[11] sky130_fd_sc_hd__buf_1
Xoutput391 net391 VGND VGND VPWR VPWR partial_sum14[9] sky130_fd_sc_hd__buf_1
XFILLER_0_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3290_ _0522_ _0597_ _0591_ _0598_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and4_1
XFILLER_0_57_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4813_ _2151_ _1794_ _1796_ _2140_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__a22oi_2
X_4744_ net349 net263 VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4675_ _1739_ _1747_ VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3626_ _2131_ _0892_ _0903_ _0887_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3557_ _0769_ _0749_ _0831_ _0837_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__and4_1
X_2508_ _2212_ _2215_ _2219_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__nand3_4
X_3488_ _0785_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_4
X_5227_ clknet_3_4__leaf_clk _0063_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
X_2439_ _2123_ _2156_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__nor2_1
X_5158_ _2155_ net86 _2011_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__mux2_1
XFILLER_0_138_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4109_ net301 net290 VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_55_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5089_ _0252_ net53 _2034_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__mux2_1
XFILLER_0_94_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_81 net353 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_92 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_70 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2790_ _2085_ _0172_ _2358_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4460_ _1541_ _1543_ _1542_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_123_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4391_ net136 net149 VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__xnor2_2
X_3411_ _0698_ _0690_ _0715_ _0657_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3342_ net5 _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__nor2_2
X_3273_ _2085_ _0495_ _0504_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__and3_1
X_5012_ _2000_ _2001_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2988_ _0344_ _0322_ _0333_ _0326_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__a221o_1
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4727_ net345 net334 VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4658_ _1715_ _1732_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput90 data7[1] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_1
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3609_ _0888_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_112_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4589_ _1651_ _1652_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_4_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3960_ _1154_ _1155_ _1157_ _1158_ _1148_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__a32o_2
XTAP_TAPCELL_ROW_18_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2911_ _0279_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_128_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3891_ _1110_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2842_ _2102_ net6 _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__and3_2
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2773_ _2357_ _0080_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4512_ _1581_ _1564_ _1583_ _1582_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__a31o_1
XFILLER_0_115_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4443_ _1552_ _1553_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nand3_2
X_4374_ net187 net200 VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__nand2_1
X_3325_ _0568_ _0603_ _0615_ _0560_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a221o_1
XFILLER_0_119_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3256_ _0526_ _0579_ _0568_ _0531_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22o_1
X_3187_ _0499_ _0502_ _0507_ _0511_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_1_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput209 net209 VGND VGND VPWR VPWR final_sum8[9] sky130_fd_sc_hd__buf_1
XFILLER_0_10_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3110_ _0448_ _0450_ _0213_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4090_ _1278_ VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__inv_2
X_3041_ _0308_ _0309_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4992_ _1985_ _1986_ VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__xor2_1
XFILLER_0_92_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3943_ _1118_ _1103_ _1119_ _1140_ _1139_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_58_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3874_ net306 net224 VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__xor2_2
XFILLER_0_116_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2825_ _0202_ VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__inv_2
XFILLER_0_90_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_116_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2756_ _0095_ _0131_ _0134_ _0089_ _0088_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__a221o_1
XFILLER_0_121_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2687_ sm2.s2.t2.A_wire\[4\] VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4426_ net19 _0321_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__and2_1
X_4357_ net195 net208 VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__xor2_2
X_4288_ _1434_ _1436_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__xor2_4
X_3308_ _0552_ _0592_ _0594_ _0554_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a22o_1
X_3239_ _0565_ VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_107_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3590_ _0873_ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__clkbuf_2
X_2610_ _2309_ _2305_ _2230_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_97_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2541_ _2229_ _2249_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2472_ _2187_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__buf_4
X_4211_ net286 net374 VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5191_ clknet_3_3__leaf_clk _0027_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
X_4142_ net557 _1314_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__xnor2_4
X_4073_ net127 net114 VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__or2_1
X_3024_ _0373_ _0333_ _0367_ _0331_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4975_ net444 net459 VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3926_ _1146_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__inv_2
XFILLER_0_18_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3857_ _0210_ net9 VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2808_ _0120_ _0162_ _0166_ _0111_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3788_ _1036_ _1001_ _1000_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__and3b_1
XFILLER_0_116_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2739_ _0089_ _0111_ _0128_ _0088_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__a211o_1
Xoutput562 net562 VGND VGND VPWR VPWR sum_out7[8] sky130_fd_sc_hd__buf_1
Xoutput551 net551 VGND VGND VPWR VPWR sum_out6[9] sky130_fd_sc_hd__buf_1
Xoutput540 net540 VGND VGND VPWR VPWR sum_out6[0] sky130_fd_sc_hd__buf_1
Xoutput573 net573 VGND VGND VPWR VPWR sum_out8[7] sky130_fd_sc_hd__buf_1
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4409_ net136 net149 VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4760_ net350 net264 VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__xnor2_4
X_3711_ _2155_ _0957_ _0971_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4691_ _1757_ _1758_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__nor2_2
XFILLER_0_28_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3642_ _0917_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_102_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3573_ _0789_ _0838_ _0839_ _0787_ _2172_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__a221o_1
XFILLER_0_113_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2524_ _2084_ _2223_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__and2_2
XFILLER_0_121_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2455_ _2149_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__clkbuf_8
X_5243_ net136 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_53_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2386_ _2107_ VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_4
X_5174_ clknet_3_4__leaf_clk _0010_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_4125_ net272 _0602_ _0604_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nand3b_1
X_4056_ _1249_ _1250_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _0331_ _0353_ _0361_ _0334_ _0328_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_104_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4958_ _1958_ _1959_ VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__nor2_1
X_3909_ net296 net215 VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__and2_1
X_4889_ _1906_ VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_22_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput370 net370 VGND VGND VPWR VPWR out2_8[2] sky130_fd_sc_hd__buf_1
Xoutput392 net392 VGND VGND VPWR VPWR partial_sum14_1[0] sky130_fd_sc_hd__buf_1
Xoutput381 net381 VGND VGND VPWR VPWR partial_sum14[12] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4812_ _1830_ _1835_ _1844_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a21o_2
XFILLER_0_7_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4743_ _1786_ _1787_ VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4674_ _1742_ _1746_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3625_ _0901_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3556_ _0749_ _0831_ _0840_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_101_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2507_ _2216_ _2217_ _2218_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__a21oi_1
X_5226_ clknet_3_5__leaf_clk _0062_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
X_3487_ _0757_ _0777_ _0778_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_47_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2438_ _2140_ _2135_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_138_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5157_ _2078_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_2369_ _2091_ VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4108_ _1292_ _1290_ _1287_ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__a21oi_2
X_5088_ _2042_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_4039_ net494 _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_55_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_93 net569 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_82 net363 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_60 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_71 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4390_ net241 _0399_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__xnor2_4
XFILLER_0_68_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3410_ _0695_ _0681_ _0685_ _0699_ _2144_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3341_ _0649_ net2 VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__and2b_1
X_3272_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_4
X_5011_ net438 net453 VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_133_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2987_ _0320_ _0317_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4726_ net345 net334 VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__nand2_2
XFILLER_0_71_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4657_ net133 net146 VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput91 data7[2] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_1
Xinput80 data5[7] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dlymetal6s2s_1
X_3608_ _0650_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_112_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4588_ _0370_ _0436_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__nor2_1
X_3539_ _0827_ _0828_ _0742_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5209_ clknet_3_7__leaf_clk _0045_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_123_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_73_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_82_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2910_ _2087_ _0239_ _0272_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o22a_1
XFILLER_0_128_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3890_ net486 _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_128_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2841_ _0212_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__xor2_4
X_2772_ _0075_ _0064_ _0145_ _0146_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__o31ai_1
XPHY_EDGE_ROW_91_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4511_ net236 net319 VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_85_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4442_ _1528_ _1530_ _1527_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4373_ _1497_ _1499_ VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__xor2_2
XFILLER_0_21_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3324_ _0562_ _0605_ _0619_ _0554_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3255_ _0571_ _0559_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__or2_1
X_3186_ _0502_ _0507_ _2121_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_1_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4709_ _1510_ _1770_ VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__nor2_1
XFILLER_0_32_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3040_ _0391_ _0392_ _0305_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4991_ _1982_ _1984_ _1981_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__a21o_1
X_3942_ net308 net226 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3873_ _0242_ _0244_ _0250_ _1079_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__o31a_1
X_2824_ _2204_ _0117_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_73_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2755_ _0142_ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_14_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2686_ _2358_ _0074_ _0081_ VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__nor3b_4
X_4425_ _1524_ _1526_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__o21ai_1
X_4356_ _1486_ VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__inv_2
X_3307_ _0539_ _0605_ _0615_ _0537_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__a221o_1
XFILLER_0_39_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4287_ _1414_ _1416_ _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__a21o_1
X_3238_ _0546_ _0543_ _0558_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__o22a_1
X_3169_ _0496_ net34 _0497_ _0499_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a2111o_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2540_ _2246_ _2248_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__and2_2
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2471_ _2172_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__buf_4
XFILLER_0_121_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4210_ _1352_ _1369_ _1370_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21o_2
X_5190_ clknet_3_3__leaf_clk _0026_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_10_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4141_ _1311_ _1313_ _0495_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_48_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4072_ _1264_ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__inv_2
XFILLER_0_92_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3023_ _0379_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4974_ _1971_ _1972_ VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__xor2_1
X_3925_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3856_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2807_ _0187_ VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__inv_2
XFILLER_0_14_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3787_ _1000_ _1001_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_131_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2738_ _0123_ _0083_ _0084_ _0126_ _0127_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput563 net563 VGND VGND VPWR VPWR sum_out7[9] sky130_fd_sc_hd__buf_1
X_2669_ net36 _0064_ net37 VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__a21oi_1
Xoutput552 net552 VGND VGND VPWR VPWR sum_out7[0] sky130_fd_sc_hd__buf_1
Xoutput541 net541 VGND VGND VPWR VPWR sum_out6[10] sky130_fd_sc_hd__buf_1
Xoutput530 net530 VGND VGND VPWR VPWR sum_out5[11] sky130_fd_sc_hd__buf_1
X_4408_ net137 net150 VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__xnor2_2
Xoutput574 net574 VGND VGND VPWR VPWR sum_out8[8] sky130_fd_sc_hd__buf_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4339_ net190 net203 VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3710_ _2161_ _0951_ _0946_ _2170_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a221o_1
XFILLER_0_83_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4690_ net135 net148 VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3641_ _0914_ _0915_ _0916_ _0904_ _0668_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__o32a_1
XFILLER_0_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3572_ _0858_ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_140 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2523_ _2122_ _2210_ _2225_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__o21a_2
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2454_ _2150_ _2141_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__nor2_1
X_5242_ net132 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_1
X_2385_ _2092_ _2100_ _2104_ _2105_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__a221o_1
X_5173_ clknet_3_4__leaf_clk _0009_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
X_4124_ _0602_ _0604_ net272 VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a21bo_1
Xinput1 addr1[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_127_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4055_ net123 net110 VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3006_ _0364_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_104_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4957_ _1955_ _1957_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3908_ _1111_ _1114_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__o21ai_4
X_4888_ _1904_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_22_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3839_ _0444_ net6 _0208_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_115_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput371 net371 VGND VGND VPWR VPWR out2_8[3] sky130_fd_sc_hd__buf_1
Xoutput360 net360 VGND VGND VPWR VPWR out2_7[3] sky130_fd_sc_hd__buf_1
Xoutput382 net382 VGND VGND VPWR VPWR partial_sum14[13] sky130_fd_sc_hd__buf_1
Xoutput393 net393 VGND VGND VPWR VPWR partial_sum14_1[10] sky130_fd_sc_hd__buf_1
XFILLER_0_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_94_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4811_ net548 _1834_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4742_ _1775_ _1780_ _1778_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4673_ net518 _1745_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__xor2_2
XFILLER_0_114_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3624_ _0899_ _0900_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3555_ _0842_ _0843_ VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__nand2_1
X_3486_ _0769_ _0774_ _0782_ _0756_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__a221o_1
X_2506_ _2211_ net25 net21 net22 VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__and4b_1
XFILLER_0_3_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5225_ clknet_3_5__leaf_clk _0061_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
X_2437_ sm2.s1.t2.A_wire\[8\] VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_102_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5156_ _2140_ net85 _2011_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__mux2_1
X_2368_ _2082_ _2089_ _2090_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and3_1
X_4107_ net122 net109 VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__nand2_1
X_5087_ _0239_ net52 _2034_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__mux2_1
X_4038_ _1239_ _1226_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_55_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_111_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_50 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_61 net234 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_83 net441 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_72 net284 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_94 net570 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput190 net190 VGND VGND VPWR VPWR final_sum7[3] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3340_ _0651_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_21_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3271_ _0590_ _0501_ _2101_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__and3b_1
X_5010_ net438 net453 VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_101_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2986_ _0345_ _0346_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__and2_2
XFILLER_0_29_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4725_ _1746_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__inv_2
XFILLER_0_71_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4656_ _1729_ _1731_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__xor2_4
Xinput81 data6[0] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
Xinput70 data4[5] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_1
X_4587_ _1672_ _1673_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__nand2_2
X_3607_ _0885_ _0886_ _0660_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nor3b_2
Xinput92 data7[3] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_1
X_3538_ net11 net13 _0738_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_112_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3469_ sm1.s2.t1.A_wire\[3\] sm1.s2.t1.A_wire\[4\] sm1.s2.t1.A_wire\[5\] VGND VGND
+ VPWR VPWR _0768_ sky130_fd_sc_hd__or3_1
X_5208_ clknet_3_7__leaf_clk _0044_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_5139_ _2069_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2840_ net8 _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__xor2_4
XFILLER_0_128_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2771_ _2102_ _0148_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__and3_2
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4510_ _1579_ net511 VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4441_ _1550_ _1551_ net385 VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4372_ _1495_ _1496_ _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__a21o_1
X_3323_ _0579_ _0594_ _0599_ _0571_ _2193_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3254_ _0578_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_2
XFILLER_0_28_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3185_ sm2.s2.t1.A_wire\[3\] _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_1_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2969_ _0329_ _0327_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__and3_2
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4708_ net378 net392 VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4639_ net230 net313 VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4990_ _1684_ net462 VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3941_ _1159_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__inv_2
XFILLER_0_58_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3872_ net305 net223 _1084_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__o21ba_1
X_2823_ _0131_ _0156_ _0198_ _0200_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a211o_1
XFILLER_0_121_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2754_ _0139_ _0140_ _0141_ _0100_ _0123_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o32a_1
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2685_ _0077_ _0078_ _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_121_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4424_ net137 net150 VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__nand2_1
X_4355_ _1483_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__xnor2_2
X_3306_ _2084_ _0608_ _0524_ _0591_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__and4_1
XFILLER_0_39_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4286_ net574 _1413_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__and2_1
X_3237_ _0515_ _0513_ _0562_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a31o_1
X_3168_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__buf_2
XFILLER_0_68_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3099_ _2202_ _0366_ _0441_ _0443_ VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_120_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_131_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2470_ sm2.s1.t2.A_wire\[10\] VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_121_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4140_ _1312_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__buf_2
X_4071_ _1261_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__xnor2_4
X_3022_ _0376_ _0377_ _0378_ _0342_ _0358_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__o32a_1
XFILLER_0_116_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4973_ _1965_ _1967_ _1964_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__o21bai_1
X_3924_ _1127_ _1129_ _1126_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3855_ net9 _0210_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__and2b_1
X_2806_ _2089_ _0092_ _0183_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_26_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3786_ _2296_ _2239_ _1028_ _2237_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a22o_1
X_2737_ _0117_ _0097_ _0120_ _0095_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2668_ net38 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_4
Xoutput520 net520 VGND VGND VPWR VPWR sum_out4[2] sky130_fd_sc_hd__buf_1
XFILLER_0_14_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput553 net553 VGND VGND VPWR VPWR sum_out7[10] sky130_fd_sc_hd__buf_1
Xoutput542 net542 VGND VGND VPWR VPWR sum_out6[11] sky130_fd_sc_hd__buf_1
Xoutput531 net531 VGND VGND VPWR VPWR sum_out5[1] sky130_fd_sc_hd__buf_1
X_4407_ _1520_ _1523_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__xor2_4
Xoutput575 net575 VGND VGND VPWR VPWR sum_out8[9] sky130_fd_sc_hd__buf_1
Xoutput564 net564 VGND VGND VPWR VPWR sum_out8[0] sky130_fd_sc_hd__buf_1
X_2599_ _2094_ _2213_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__and3_2
X_4338_ _1331_ _1338_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__xor2_2
X_4269_ _1402_ _1403_ _1401_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_70_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3640_ _0695_ _0890_ _0910_ _0677_ _0909_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a221o_1
XFILLER_0_125_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3571_ _0854_ _0855_ _0856_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__o31a_1
XFILLER_0_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2522_ _2232_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__inv_2
XFILLER_0_3_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ _2167_ _2169_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__and2_2
XFILLER_0_121_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5241_ net124 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__clkbuf_2
X_2384_ _2084_ _2090_ _2095_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__and3_1
X_5172_ clknet_3_4__leaf_clk _0008_ VGND VGND VPWR VPWR sm1.s2.t2.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_4123_ _0514_ _0596_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nor2_2
Xinput2 addr1[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_4
X_4054_ _1249_ _1250_ VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__xor2_1
X_3005_ _0344_ _0342_ _0357_ _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_78_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4956_ _1955_ _1957_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3907_ net295 net214 VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__nand2_1
X_4887_ net420 net406 VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_22_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_50_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3838_ _0982_ _0983_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__xor2_4
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3769_ _1022_ VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__inv_2
XFILLER_0_14_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput361 net361 VGND VGND VPWR VPWR out2_7[4] sky130_fd_sc_hd__buf_1
Xoutput350 net350 VGND VGND VPWR VPWR out2_6[4] sky130_fd_sc_hd__buf_1
Xoutput372 net372 VGND VGND VPWR VPWR out2_8[4] sky130_fd_sc_hd__buf_1
XFILLER_0_10_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput394 net394 VGND VGND VPWR VPWR partial_sum14_1[11] sky130_fd_sc_hd__buf_1
Xoutput383 net383 VGND VGND VPWR VPWR partial_sum14[1] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_58_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4810_ _1827_ _1836_ _1842_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4741_ net163 net176 VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4672_ _1729_ _1731_ _1744_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__o21a_1
XFILLER_0_113_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3623_ _2093_ _0672_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3554_ _0769_ _0832_ _0834_ _0771_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3485_ _0780_ _0759_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__and2_1
X_2505_ net21 net22 VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__and2b_1
X_5224_ clknet_3_5__leaf_clk _0060_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[7\] sky130_fd_sc_hd__dfxtp_1
X_2436_ _2154_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_138_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2367_ sm2.s1.t2.A_wire\[3\] VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__buf_2
X_5155_ _2077_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_110_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5086_ _2041_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_4106_ _1291_ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__inv_2
X_4037_ _1223_ _1224_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4939_ _1944_ _1945_ VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_40 net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_84 net462 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_51 net125 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_73 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_95 net571 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_132_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput180 net180 VGND VGND VPWR VPWR final_sum6[6] sky130_fd_sc_hd__buf_1
Xoutput191 net191 VGND VGND VPWR VPWR final_sum7[4] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_128_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3270_ _2110_ _0501_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__and3_2
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2985_ _0344_ _0335_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4724_ _1681_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__inv_2
XFILLER_0_29_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4655_ _1704_ _1707_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__a21oi_2
Xinput82 data6[1] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
Xinput71 data4[6] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_2
Xinput60 data3[3] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4586_ net248 net332 VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__nand2_1
X_3606_ net3 net5 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__and2b_1
Xinput93 data7[4] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_1
X_3537_ net11 net12 net15 net13 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_112_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3468_ _0763_ _0766_ _0737_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__o21a_1
X_5207_ clknet_3_7__leaf_clk _0043_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
X_2419_ _2127_ _2133_ _2138_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__or3_1
X_3399_ sm1.s1.t1.A_wire\[7\] sm1.s1.t1.A_wire\[8\] _0688_ VGND VGND VPWR VPWR _0706_
+ sky130_fd_sc_hd__or3_1
X_5138_ _2247_ net76 _2067_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5069_ _2032_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_123_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_128_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2770_ _0075_ _0151_ _0145_ _0152_ _0076_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_26_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_130_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4440_ net385 _1550_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__nand3_1
XFILLER_0_41_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4371_ net185 net198 VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3322_ _0637_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_2
XFILLER_0_119_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3253_ _0560_ _0543_ _0575_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__o22a_1
X_3184_ sm2.s2.t1.A_wire\[4\] VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_1_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2968_ _0310_ _0302_ _0300_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4707_ _1509_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__inv_2
X_4638_ _1687_ _1690_ _1688_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__o21a_2
X_2899_ _0264_ _0267_ _0268_ _0231_ _2088_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4569_ _1656_ _1632_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3940_ _1148_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_426 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3871_ net305 net223 VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2822_ _0134_ _0162_ _0199_ _2193_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__a211o_1
XFILLER_0_85_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2753_ _0095_ _0134_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2684_ _2120_ _0079_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4423_ _1533_ net509 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__xnor2_4
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4354_ _1480_ _1481_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a21oi_2
X_3305_ _0546_ _0599_ _0603_ _0547_ _2144_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__a221o_1
X_4285_ _1427_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__xor2_4
X_3236_ _0560_ _0519_ _0527_ _0552_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a22o_1
X_3167_ net31 VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_2
X_3098_ _0367_ _0413_ _0408_ _0373_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_120_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_131_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4070_ _1258_ _1260_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a21o_1
X_3021_ _0331_ _0361_ _0367_ _0334_ _0328_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a221o_1
XFILLER_0_116_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4972_ _1578_ _1919_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3923_ _1142_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3854_ _1083_ _1085_ VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__xnor2_4
XFILLER_0_58_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2805_ _0102_ _0179_ _0166_ _0105_ _0185_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a221o_1
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3785_ _1035_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__inv_2
X_2736_ _0124_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__and2_2
XFILLER_0_6_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2667_ _2357_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__inv_2
XFILLER_0_112_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput510 net510 VGND VGND VPWR VPWR sum_out3[4] sky130_fd_sc_hd__buf_1
XFILLER_0_14_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput554 net554 VGND VGND VPWR VPWR sum_out7[11] sky130_fd_sc_hd__buf_1
Xoutput543 net543 VGND VGND VPWR VPWR sum_out6[1] sky130_fd_sc_hd__buf_1
Xoutput532 net532 VGND VGND VPWR VPWR sum_out5[2] sky130_fd_sc_hd__buf_1
Xoutput521 net521 VGND VGND VPWR VPWR sum_out4[3] sky130_fd_sc_hd__buf_1
X_4406_ _1521_ _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__and2b_1
Xoutput565 net565 VGND VGND VPWR VPWR sum_out8[10] sky130_fd_sc_hd__buf_1
X_2598_ _2291_ _2293_ _2298_ _2212_ _2222_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__o2111a_2
X_4337_ _1471_ VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__inv_2
X_4268_ _1417_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__or2b_2
XTAP_TAPCELL_ROW_70_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3219_ _0515_ _0513_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__and3_1
X_4199_ _1359_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_134_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3570_ _2110_ _0757_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2521_ _2227_ _2228_ _2229_ _2230_ _2231_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5240_ net123 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__buf_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _2168_ _2159_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2383_ sm2.s1.t2.A_wire\[4\] VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__clkbuf_4
X_5171_ clknet_3_5__leaf_clk _0007_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4122_ net281 net369 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__xor2_4
X_4053_ net123 net110 VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__xnor2_2
Xinput3 addr1[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_4
X_3004_ _0358_ _0322_ _0333_ _0352_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__a221o_1
XFILLER_0_36_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4955_ _1515_ net455 VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3906_ _1128_ _1129_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__xor2_4
X_4886_ net420 net406 VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3837_ _2226_ _2303_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__xor2_4
XFILLER_0_61_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3768_ _1020_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__xnor2_4
X_2719_ sm2.s2.t2.A_wire\[7\] _0103_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__xor2_4
XFILLER_0_131_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3699_ _2178_ _0939_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_1
XFILLER_0_131_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput362 net362 VGND VGND VPWR VPWR out2_7[5] sky130_fd_sc_hd__buf_1
Xoutput351 net351 VGND VGND VPWR VPWR out2_6[5] sky130_fd_sc_hd__buf_1
Xoutput340 net340 VGND VGND VPWR VPWR out2_5[5] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput373 net373 VGND VGND VPWR VPWR out2_8[5] sky130_fd_sc_hd__buf_1
Xoutput384 net384 VGND VGND VPWR VPWR partial_sum14[2] sky130_fd_sc_hd__buf_1
Xoutput395 net395 VGND VGND VPWR VPWR partial_sum14_1[12] sky130_fd_sc_hd__buf_1
XFILLER_0_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4740_ _1784_ _1785_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__nor2_4
XFILLER_0_28_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4671_ _1728_ net517 VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3622_ net3 _0669_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3553_ _0758_ _0838_ _0839_ _0757_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3484_ _0779_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__and2_2
X_2504_ _2211_ net25 net24 VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__a21o_1
X_5223_ clknet_3_7__leaf_clk _0059_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
X_2435_ _2086_ _2105_ _2143_ _2153_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__o22a_1
X_5154_ _2126_ net84 _2067_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__mux2_1
X_4105_ _1288_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_47_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2366_ _2088_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5085_ _0231_ net51 _2034_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_16_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4036_ _1238_ VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4938_ net422 net408 VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__xnor2_1
XANTENNA_30 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_41 net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4869_ _1892_ VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_25_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_52 net128 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_63 net252 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_74 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_96 _1421_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_85 net488 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput170 net170 VGND VGND VPWR VPWR final_sum5[9] sky130_fd_sc_hd__buf_1
Xoutput181 net181 VGND VGND VPWR VPWR final_sum6[7] sky130_fd_sc_hd__buf_1
Xoutput192 net192 VGND VGND VPWR VPWR final_sum7[5] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_191 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ sm1.s2.t2.A_wire\[6\] _0335_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__or2_2
X_4723_ _1774_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_32_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4654_ _1698_ net527 VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__and2b_1
Xinput72 data4[7] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_2
Xinput61 data3[4] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
Xinput50 data2[1] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_2
XFILLER_0_12_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3605_ _0672_ net3 VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and2b_1
X_4585_ net248 net332 VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__or2_1
Xinput94 data7[5] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_1
Xinput83 data6[2] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
X_3536_ _0749_ _0747_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5206_ clknet_3_7__leaf_clk _0042_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_3467_ _0749_ _0762_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and3_2
X_2418_ _2090_ _2111_ _2137_ _2100_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__a22o_1
X_3398_ _0695_ _0687_ _0694_ _0699_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a221o_1
X_5137_ _2068_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5068_ _0668_ net43 _2023_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__mux2_1
X_4019_ _1223_ _1224_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_123_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_446 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4370_ net186 net199 VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__xor2_2
X_3321_ _2088_ _0546_ _0633_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__o22a_1
XFILLER_0_95_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3252_ _0571_ _0527_ _0568_ _0526_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a221o_1
XFILLER_0_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3183_ _0498_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_1_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2967_ _0310_ _0302_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__or2_2
XFILLER_0_44_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4706_ _1767_ _1769_ _1765_ VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__a21o_1
X_2898_ _0233_ _0248_ _0255_ _0257_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4637_ _1686_ _1691_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4568_ net388 net402 VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__and2_1
X_3519_ _0793_ _0777_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__o21a_1
X_4499_ net140 net153 VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3870_ _1087_ _1089_ _0208_ net497 VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__o211a_2
X_2821_ _0132_ _0160_ _0166_ _0126_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2752_ _0084_ _0131_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2683_ net36 net37 VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__nor2_1
X_4422_ _1534_ _1535_ VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__xnor2_4
XFILLER_0_1_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4353_ net193 net206 VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4284_ _1431_ _1432_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__xnor2_4
X_3304_ _0622_ VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_4
X_3235_ _0559_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__and2_2
X_3166_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__inv_2
X_3097_ _0313_ _0384_ _0395_ _2193_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_120_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3999_ _1207_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_107_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_416 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3020_ _0373_ _0322_ _0333_ _0366_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_19_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4971_ _1970_ VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3922_ _0247_ _1087_ _1089_ _0239_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3853_ _1079_ _1080_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__a21bo_1
X_2804_ _0117_ _0154_ _0184_ _2188_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a211o_1
XFILLER_0_128_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3784_ _1030_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__xnor2_4
X_2735_ _0123_ _0118_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2666_ sm2.s2.t2.A_wire\[3\] VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__buf_2
XFILLER_0_124_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput511 net511 VGND VGND VPWR VPWR sum_out3[5] sky130_fd_sc_hd__buf_1
Xoutput500 net500 VGND VGND VPWR VPWR sum_out2[6] sky130_fd_sc_hd__buf_1
Xoutput544 net544 VGND VGND VPWR VPWR sum_out6[2] sky130_fd_sc_hd__buf_1
Xoutput533 net533 VGND VGND VPWR VPWR sum_out5[3] sky130_fd_sc_hd__buf_1
Xoutput522 net522 VGND VGND VPWR VPWR sum_out4[4] sky130_fd_sc_hd__buf_1
X_4405_ net242 _0404_ _0406_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__or3_1
Xoutput566 net566 VGND VGND VPWR VPWR sum_out8[11] sky130_fd_sc_hd__buf_1
Xoutput555 net555 VGND VGND VPWR VPWR sum_out7[1] sky130_fd_sc_hd__buf_1
XFILLER_0_112_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2597_ _2294_ _2222_ _2296_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__o31a_1
X_4336_ _1468_ _1470_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__xnor2_2
X_4267_ net279 net366 VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_70_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3218_ sm2.s2.t1.A_wire\[7\] _0536_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__xor2_4
X_4198_ _1342_ _1343_ _1358_ _1340_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a31o_1
X_3149_ _0485_ VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_2
XFILLER_0_96_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_120 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2520_ _2110_ _2208_ _2220_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2451_ sm2.s1.t2.A_wire\[9\] VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_87_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5170_ clknet_3_4__leaf_clk _0006_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[9\] sky130_fd_sc_hd__dfxtp_2
X_2382_ _2082_ _2102_ _2103_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__and3_2
XFILLER_0_127_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4121_ _1298_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkinv_4
XFILLER_0_46_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4052_ net301 net290 VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__nand2_1
Xinput4 addr1[3] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_2
X_3003_ _0320_ _0317_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4954_ _1955_ _1956_ VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__nor2_1
XFILLER_0_19_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3905_ _1098_ _1107_ _1106_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a21o_2
XFILLER_0_59_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4885_ _1900_ _1903_ _1899_ VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_22_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3836_ _1076_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3767_ net258 net343 _1015_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a21o_1
X_2718_ _0102_ _0097_ _0105_ _0095_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_89_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3698_ _2155_ _0942_ _0951_ _2137_ _0949_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a221o_1
XFILLER_0_112_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2649_ _2270_ _2324_ _2332_ _2265_ _2187_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__a221o_1
Xoutput352 net352 VGND VGND VPWR VPWR out2_6[6] sky130_fd_sc_hd__buf_1
Xoutput341 net341 VGND VGND VPWR VPWR out2_5[6] sky130_fd_sc_hd__buf_1
Xoutput330 net330 VGND VGND VPWR VPWR out2_4[6] sky130_fd_sc_hd__buf_1
XFILLER_0_100_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput374 net374 VGND VGND VPWR VPWR out2_8[6] sky130_fd_sc_hd__buf_1
Xoutput363 net363 VGND VGND VPWR VPWR out2_7[6] sky130_fd_sc_hd__buf_1
XFILLER_0_77_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput385 net385 VGND VGND VPWR VPWR partial_sum14[3] sky130_fd_sc_hd__buf_1
Xoutput396 net396 VGND VGND VPWR VPWR partial_sum14_1[13] sky130_fd_sc_hd__buf_1
X_4319_ _1458_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_98_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4670_ _0386_ _0446_ _1743_ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__a21oi_4
XFILLER_0_22_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3621_ net3 _0654_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3552_ _0737_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__and2_1
X_2503_ _2213_ net22 net25 _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__a211o_1
XFILLER_0_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3483_ _0780_ _0768_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5222_ clknet_3_7__leaf_clk _0058_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_2434_ _2144_ _2148_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__or3_1
X_5153_ _2076_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2365_ _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_138_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4104_ _1283_ _1285_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__a21o_2
X_5084_ _2040_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4035_ _1221_ _1222_ _1219_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_69_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4937_ _1942_ _1941_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_31 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4868_ _1879_ _1881_ _1876_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__o21a_1
XANTENNA_20 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_42 net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_64 net254 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_75 net309 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3819_ _1061_ _1058_ _1063_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__or3_1
X_4799_ net548 _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__xor2_2
XANTENNA_86 net489 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_97 _1617_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput160 net160 VGND VGND VPWR VPWR final_sum5[11] sky130_fd_sc_hd__buf_1
XFILLER_0_30_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput182 net182 VGND VGND VPWR VPWR final_sum6[8] sky130_fd_sc_hd__buf_1
Xoutput171 net171 VGND VGND VPWR VPWR final_sum6[0] sky130_fd_sc_hd__buf_1
Xoutput193 net193 VGND VGND VPWR VPWR final_sum7[6] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_128_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_308 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2983_ sm1.s2.t2.A_wire\[6\] VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4722_ _1546_ _1547_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_32_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput40 addr8[4] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_4
XFILLER_0_126_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4653_ net517 _1728_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__xor2_4
Xinput73 data5[0] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_1
Xinput62 data3[5] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
Xinput51 data2[2] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_2
X_3604_ _0444_ _0807_ _0881_ _0884_ VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__o22a_2
X_4584_ _1669_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__or2_4
Xinput95 data7[6] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_1
Xinput84 data6[3] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
X_3535_ _0743_ _0823_ net11 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3466_ _0764_ net13 _0738_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5205_ clknet_3_7__leaf_clk _0041_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
X_2417_ _2135_ _2136_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3397_ _0703_ _0660_ _0661_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__and3_1
X_5136_ _2237_ net75 _2067_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5067_ _2031_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4018_ _0285_ _1087_ _1089_ _0280_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_123_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3320_ _0571_ _0592_ _0634_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a211o_1
X_3251_ _0531_ _0562_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__and2_1
XFILLER_0_119_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3182_ _0514_ VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2966_ _0316_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__nor2_2
XFILLER_0_8_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4705_ _1767_ _1769_ VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__xnor2_2
X_2897_ _0261_ _0221_ _0265_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__a211o_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4636_ _1697_ _1713_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__a21o_2
XFILLER_0_44_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4567_ net388 net402 VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__or2_1
X_3518_ _0756_ _0809_ _0810_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__a211o_1
X_4498_ _1595_ _1600_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__xnor2_4
X_3449_ net13 _0745_ _0746_ _0747_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__o32a_1
X_5119_ _0092_ net99 _2056_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2820_ _0123_ _0179_ _0177_ _0120_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_14_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2751_ _0132_ _0097_ _0126_ _0089_ _0088_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__a221o_1
XFILLER_0_121_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ _0075_ net37 _0064_ _0071_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4421_ _0776_ _0852_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_76_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4352_ _1390_ net207 VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__xor2_2
X_4283_ _1411_ _1412_ _1410_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__a21o_2
X_3303_ _0616_ _0618_ _0621_ _0516_ _2085_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__o32a_1
XFILLER_0_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3234_ _0560_ _0551_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_72_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3165_ net35 VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_2
X_3096_ _0375_ _0411_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ _1205_ _1206_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2949_ net16 _0300_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__or2_2
XFILLER_0_91_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4619_ net248 net332 VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_131_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_109_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4970_ _1968_ _1969_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_127_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3921_ _1139_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3852_ net304 net222 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__nand2_1
X_2803_ _0109_ _0160_ _0162_ _0111_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3783_ _1032_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2734_ sm2.s2.t2.A_wire\[9\] _0118_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput501 net501 VGND VGND VPWR VPWR sum_out2[7] sky130_fd_sc_hd__buf_1
X_2665_ _2356_ VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_136_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput545 net545 VGND VGND VPWR VPWR sum_out6[3] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput534 net534 VGND VGND VPWR VPWR sum_out5[4] sky130_fd_sc_hd__buf_1
Xoutput523 net523 VGND VGND VPWR VPWR sum_out4[5] sky130_fd_sc_hd__buf_1
Xoutput512 net512 VGND VGND VPWR VPWR sum_out3[6] sky130_fd_sc_hd__buf_1
X_2596_ net21 net22 net25 net23 VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__or4b_1
X_4404_ _0404_ _0406_ net242 VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__o21a_1
Xoutput567 net567 VGND VGND VPWR VPWR sum_out8[1] sky130_fd_sc_hd__buf_1
Xoutput556 net556 VGND VGND VPWR VPWR sum_out7[2] sky130_fd_sc_hd__buf_1
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4335_ _1466_ _1467_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4266_ net279 net366 VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3217_ sm2.s2.t1.A_wire\[7\] VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__buf_2
X_4197_ _1342_ _1343_ _1358_ _1340_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a311oi_2
X_3148_ _0482_ _0483_ _0484_ _0469_ _0252_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o32a_1
XFILLER_0_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3079_ _0358_ _0400_ _0405_ _0361_ _2188_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a221o_1
XFILLER_0_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_53_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_110 net274 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_138_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2450_ sm2.s1.t2.A_wire\[9\] _2159_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__or2_1
XFILLER_0_121_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2381_ _2096_ _2098_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__xnor2_2
X_4120_ _0514_ _0596_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__xnor2_4
X_4051_ _1248_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_1
XFILLER_0_36_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput5 addr1[4] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_2
XFILLER_0_127_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3002_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__and2_2
XFILLER_0_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4953_ net434 net449 VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3904_ _1126_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4884_ _1900_ _1903_ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_50_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3835_ _0444_ _2213_ _2208_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3766_ _1018_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__nor2_2
X_2717_ sm2.s2.t2.A_wire\[7\] VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__buf_4
XFILLER_0_124_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3697_ _0962_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput353 net353 VGND VGND VPWR VPWR out2_6[7] sky130_fd_sc_hd__buf_1
Xoutput342 net342 VGND VGND VPWR VPWR out2_5[7] sky130_fd_sc_hd__buf_1
X_2648_ _2255_ _2328_ _2329_ _2261_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__a22o_1
Xoutput331 net331 VGND VGND VPWR VPWR out2_4[7] sky130_fd_sc_hd__buf_1
Xoutput320 net320 VGND VGND VPWR VPWR out2_3[7] sky130_fd_sc_hd__buf_1
Xoutput375 net375 VGND VGND VPWR VPWR out2_8[7] sky130_fd_sc_hd__buf_1
Xoutput364 net364 VGND VGND VPWR VPWR out2_7[7] sky130_fd_sc_hd__buf_1
XFILLER_0_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput386 net386 VGND VGND VPWR VPWR partial_sum14[4] sky130_fd_sc_hd__buf_1
X_2579_ _2283_ VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_2
XFILLER_0_100_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput397 net397 VGND VGND VPWR VPWR partial_sum14_1[1] sky130_fd_sc_hd__buf_1
X_4318_ net554 _1454_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__and2_1
X_4249_ _1402_ _1403_ VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_58_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_123_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3620_ _2084_ _0672_ _0892_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__and3_2
X_3551_ _0743_ _0745_ _2121_ _0764_ _0738_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a2111oi_2
X_2502_ net21 _2211_ net22 VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3482_ sm1.s2.t1.A_wire\[6\] VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__buf_2
XFILLER_0_121_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5221_ clknet_3_5__leaf_clk _0057_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[4\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_121_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2433_ _2124_ _2150_ _2151_ _2100_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_114_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5152_ _2116_ net83 _2067_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__mux2_1
X_2364_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__buf_4
X_4103_ _1241_ _1246_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__nor2_1
X_5083_ _0217_ net50 _2034_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4034_ _1235_ _1237_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_69_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4936_ net421 net407 VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_32 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4867_ _1875_ _1889_ _1890_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__a21o_2
XANTENNA_21 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_10 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_54 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_65 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_43 net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3818_ _1061_ _1058_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__o21ai_2
X_4798_ _2137_ _1794_ _1796_ _2126_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__a22o_1
XANTENNA_87 net497 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_98 _1695_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_76 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_132_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3749_ _0995_ _0996_ _1005_ _0997_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__o31a_1
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput161 net161 VGND VGND VPWR VPWR final_sum5[12] sky130_fd_sc_hd__buf_1
Xoutput150 net150 VGND VGND VPWR VPWR final_sum4[2] sky130_fd_sc_hd__buf_1
XFILLER_0_30_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput194 net194 VGND VGND VPWR VPWR final_sum7[7] sky130_fd_sc_hd__buf_1
Xoutput172 net172 VGND VGND VPWR VPWR final_sum6[10] sky130_fd_sc_hd__buf_1
Xoutput183 net183 VGND VGND VPWR VPWR final_sum6[9] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_99 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2982_ _0324_ _0331_ _0337_ _0334_ _0328_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a221o_1
XFILLER_0_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4721_ _1328_ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__inv_2
XFILLER_0_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4652_ _0305_ _0375_ _1539_ _0373_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__a22oi_4
Xinput30 addr6[4] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
X_3603_ _0816_ _0844_ _0849_ _0809_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput63 data3[6] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
Xinput52 data2[3] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_2
Xinput41 data1[0] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
XFILLER_0_126_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4583_ _1663_ _1643_ _1668_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput96 data7[7] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_1
Xinput85 data6[4] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
Xinput74 data5[1] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
X_3534_ _0743_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nor2_1
XFILLER_0_101_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3465_ net11 VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__buf_2
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5204_ clknet_3_7__leaf_clk _0040_ VGND VGND VPWR VPWR sm2.s2.t2.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_2416_ _2126_ _2115_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__nand2_1
X_3396_ sm1.s1.t1.A_wire\[8\] VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__clkbuf_4
X_5135_ _2011_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_4_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5066_ _0658_ net42 _2023_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4017_ _1221_ _1222_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_123_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4919_ _1486_ net417 VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3250_ _0574_ _0567_ _0543_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3181_ _0495_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2_8
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2965_ _2149_ _0321_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nor2_1
X_4704_ _1754_ _1763_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_56_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2896_ _0239_ _0220_ _0236_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4635_ net144 net157 VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4566_ net389 net403 VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__xnor2_1
X_3517_ _0807_ _0759_ _0766_ _0796_ _0763_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a221o_1
XFILLER_0_102_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4497_ _1596_ net523 VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__xnor2_2
X_3448_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__clkbuf_4
X_3379_ sm1.s1.t1.A_wire\[6\] _0675_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__or2_4
X_5118_ _2058_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5049_ _0319_ net66 _2012_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2750_ _0138_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__inv_2
X_2681_ _0076_ _0065_ net40 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__and3b_1
XFILLER_0_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4420_ net231 net314 _1518_ _1517_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__a31o_2
XFILLER_0_30_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4351_ _1482_ VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__inv_2
XFILLER_0_39_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4282_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__inv_2
X_3302_ _0539_ _0603_ _0619_ _0517_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a221o_1
X_3233_ sm2.s2.t1.A_wire\[9\] VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_72_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3164_ net33 VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_55_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3095_ _0440_ VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_89_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3997_ _1202_ _1186_ _1204_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__or3_1
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2948_ _0308_ _0309_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4618_ _1699_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__or2_2
X_2879_ _2187_ _0208_ _0242_ _0244_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_130_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4549_ _1634_ net513 VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3920_ _1118_ _1103_ _1119_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__a31o_1
XFILLER_0_58_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3851_ net305 net223 VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2802_ _0120_ _0156_ _0177_ _0094_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3782_ _0992_ _0993_ _1031_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2733_ sm2.s2.t2.A_wire\[9\] VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_116_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput502 net502 VGND VGND VPWR VPWR sum_out2[8] sky130_fd_sc_hd__buf_1
X_2664_ _2204_ _2279_ _2355_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__o21a_1
XFILLER_0_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput535 net535 VGND VGND VPWR VPWR sum_out5[5] sky130_fd_sc_hd__buf_1
XFILLER_0_112_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput524 net524 VGND VGND VPWR VPWR sum_out4[6] sky130_fd_sc_hd__buf_1
Xoutput513 net513 VGND VGND VPWR VPWR sum_out3[7] sky130_fd_sc_hd__buf_1
X_4403_ _0399_ net241 VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__and2b_2
X_2595_ _2295_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__buf_4
Xoutput568 net568 VGND VGND VPWR VPWR sum_out8[2] sky130_fd_sc_hd__buf_1
Xoutput557 net557 VGND VGND VPWR VPWR sum_out7[3] sky130_fd_sc_hd__buf_1
Xoutput546 net546 VGND VGND VPWR VPWR sum_out6[4] sky130_fd_sc_hd__buf_1
XFILLER_0_112_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4334_ _1303_ _1308_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4265_ _1414_ _1416_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__xor2_4
XFILLER_0_5_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3216_ _0531_ _0524_ _0526_ _0539_ _0529_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a221o_1
X_4196_ net276 net363 VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__xnor2_1
X_3147_ _0263_ _0463_ _0464_ _0261_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3078_ _0426_ VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_119_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_100 net19 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_111 net356 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_138_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_138_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2380_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__clkbuf_4
X_4050_ net482 _1245_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__and2_1
Xinput6 addr2[0] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_4
X_3001_ _0352_ _0345_ _0358_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4952_ net434 _1904_ _1905_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__and3_1
XFILLER_0_129_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4883_ _1891_ _1901_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__a21o_2
X_3903_ _1122_ _1123_ _1125_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3834_ _1075_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_50_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3765_ net259 net344 VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__and2_1
X_3696_ _2116_ _0957_ _0959_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__o22a_1
X_2716_ _0108_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__inv_2
X_2647_ _2342_ VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput310 net310 VGND VGND VPWR VPWR out2_2[8] sky130_fd_sc_hd__buf_1
XFILLER_0_112_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput343 net343 VGND VGND VPWR VPWR out2_5[8] sky130_fd_sc_hd__buf_1
Xoutput332 net332 VGND VGND VPWR VPWR out2_4[8] sky130_fd_sc_hd__buf_1
Xoutput321 net321 VGND VGND VPWR VPWR out2_3[8] sky130_fd_sc_hd__buf_1
Xoutput376 net376 VGND VGND VPWR VPWR out2_8[8] sky130_fd_sc_hd__buf_1
Xoutput365 net365 VGND VGND VPWR VPWR out2_7[8] sky130_fd_sc_hd__buf_1
Xoutput354 net354 VGND VGND VPWR VPWR out2_6[8] sky130_fd_sc_hd__buf_1
Xsub_module16_580 VGND VGND VPWR VPWR sub_module16_580/HI out1_2[0] sky130_fd_sc_hd__conb_1
Xoutput387 net387 VGND VGND VPWR VPWR partial_sum14[5] sky130_fd_sc_hd__buf_1
X_2578_ _2261_ _2252_ _2282_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__o21a_1
X_4317_ net566 _1457_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__xnor2_4
Xoutput398 net398 VGND VGND VPWR VPWR partial_sum14_1[2] sky130_fd_sc_hd__buf_1
X_4248_ net277 net364 _1381_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_93_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4179_ _1311_ _0524_ _1313_ _0522_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3550_ _0749_ _0831_ _0837_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__and3_2
XFILLER_0_24_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2501_ net21 VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__buf_2
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5220_ clknet_3_5__leaf_clk _0056_ VGND VGND VPWR VPWR sm2.s1.t2.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_3481_ sm1.s2.t1.A_wire\[6\] _0768_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__or2_2
X_2432_ sm2.s1.t2.A_wire\[7\] _2135_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_114_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5151_ _2075_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_2363_ _2085_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__buf_4
XFILLER_0_51_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5082_ _2039_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_4102_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__nor2_2
XFILLER_0_47_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4033_ _1213_ _1216_ _1236_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_69_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4935_ net421 net407 VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_11 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4866_ net159 net172 VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__and2_1
XANTENNA_22 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_55 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4797_ _1831_ _1833_ VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__xnor2_4
XANTENNA_33 net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_66 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_44 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3817_ _1022_ _1062_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__xor2_1
XANTENNA_88 net545 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_77 net334 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3748_ net255 net340 VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__and2_1
XANTENNA_99 _1695_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3679_ _2145_ _0939_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput151 net151 VGND VGND VPWR VPWR final_sum4[3] sky130_fd_sc_hd__buf_1
Xoutput140 net140 VGND VGND VPWR VPWR final_sum3[5] sky130_fd_sc_hd__buf_1
XFILLER_0_30_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput184 net184 VGND VGND VPWR VPWR final_sum7[0] sky130_fd_sc_hd__buf_1
Xoutput173 net173 VGND VGND VPWR VPWR final_sum6[11] sky130_fd_sc_hd__buf_1
Xoutput195 net195 VGND VGND VPWR VPWR final_sum7[8] sky130_fd_sc_hd__buf_1
Xoutput162 net162 VGND VGND VPWR VPWR final_sum5[1] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_413 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_12_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2981_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_4
X_4720_ _1742_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_32_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4651_ _1726_ _1727_ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__xnor2_4
Xinput31 addr7[0] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 addr4[4] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_4
X_3602_ _0883_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_4_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput64 data3[7] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
Xinput53 data2[4] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_2
Xinput42 data1[1] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_2
XFILLER_0_114_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4582_ _1663_ _1643_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput97 data8[0] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
Xinput86 data6[5] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
Xinput75 data5[2] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
X_3533_ net12 net15 VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3464_ _0753_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nor2_2
XFILLER_0_12_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2415_ _2134_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__buf_2
X_5203_ clknet_3_3__leaf_clk _0039_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5134_ _2066_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
X_3395_ _0702_ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5065_ _2030_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_4016_ _1197_ _1200_ _1198_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o21a_2
XFILLER_0_79_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4918_ _1924_ _1927_ _1928_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4849_ _1866_ _1873_ _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3180_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_109_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2964_ sm1.s2.t2.A_wire\[5\] VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4703_ _1291_ net395 VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__and2b_1
XFILLER_0_127_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2895_ _0215_ _0236_ _0247_ _2187_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__a31o_1
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4634_ net144 net157 VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4565_ _1647_ _1654_ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__xor2_2
X_3516_ _0803_ _0774_ _0801_ _0772_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4496_ _1598_ _1599_ VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__xnor2_4
X_3447_ net11 net13 VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__or2_1
X_3378_ _0665_ _0661_ _0666_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and3_2
X_5117_ _0082_ net98 _2056_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__mux2_1
XFILLER_0_109_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5048_ _2021_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2680_ _0075_ _0064_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4350_ _1480_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__xnor2_2
X_3301_ _0537_ _0597_ _0504_ _0591_ _2122_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a41o_1
X_4281_ _1428_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__or2_1
X_3232_ sm2.s2.t1.A_wire\[9\] _0551_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__or2_1
X_3163_ net32 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_72_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3094_ _0437_ _0438_ _0439_ _0358_ _2202_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__o32a_1
XFILLER_0_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3996_ _1202_ _1186_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2947_ _0302_ net20 _0310_ _0300_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__and4b_1
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4617_ net249 net333 VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__and2_1
X_2878_ _0216_ _0247_ _0248_ _0208_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a221o_1
XFILLER_0_130_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4548_ _1640_ _1641_ VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__nor2_1
XFILLER_0_13_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4479_ _1581_ _1564_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3850_ _1081_ _1082_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2801_ _0182_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__buf_2
X_3781_ _0992_ _0993_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_4_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2732_ _0122_ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_2
XFILLER_0_6_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2663_ _2278_ _2328_ _2332_ _2285_ _2352_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_117_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput536 net536 VGND VGND VPWR VPWR sum_out5[6] sky130_fd_sc_hd__buf_1
XFILLER_0_112_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput525 net525 VGND VGND VPWR VPWR sum_out4[7] sky130_fd_sc_hd__buf_1
Xoutput514 net514 VGND VGND VPWR VPWR sum_out3[8] sky130_fd_sc_hd__buf_1
X_4402_ _1516_ _1519_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__xnor2_4
Xoutput503 net503 VGND VGND VPWR VPWR sum_out2[9] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_74_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2594_ net24 net25 VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__and2b_1
Xoutput569 net569 VGND VGND VPWR VPWR sum_out8[3] sky130_fd_sc_hd__buf_1
Xoutput558 net558 VGND VGND VPWR VPWR sum_out7[4] sky130_fd_sc_hd__buf_1
Xoutput547 net547 VGND VGND VPWR VPWR sum_out6[5] sky130_fd_sc_hd__buf_1
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4333_ net190 net203 VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__xnor2_2
X_4264_ _1393_ _1399_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3215_ _0544_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_4
X_4195_ _1339_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__inv_2
X_3146_ _0270_ _0455_ _0459_ _0255_ _0461_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a221o_1
X_3077_ _0422_ _0424_ _0425_ _0326_ _2088_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__o32a_1
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_59_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3979_ _1171_ _1173_ _1189_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__nor3_1
XFILLER_0_134_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_101 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_112 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput7 addr2[1] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_2
XFILLER_0_127_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3000_ sm1.s2.t2.A_wire\[7\] sm1.s2.t2.A_wire\[8\] _0345_ VGND VGND VPWR VPWR _0359_
+ sky130_fd_sc_hd__or3_4
X_4951_ _1951_ _1954_ _1952_ VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4882_ net160 net173 VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__and2_1
X_3902_ _1122_ _1123_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3833_ net530 _1074_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_119_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3764_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__inv_2
X_3695_ _2137_ _0946_ _0945_ _2126_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__a221o_1
X_2715_ _0082_ _0100_ _0101_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__o22ai_4
X_2646_ _2338_ _2339_ _2341_ _2247_ _2086_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__o32a_1
XFILLER_0_14_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput300 net300 VGND VGND VPWR VPWR out2[9] sky130_fd_sc_hd__buf_1
Xoutput344 net344 VGND VGND VPWR VPWR out2_5[9] sky130_fd_sc_hd__buf_1
Xoutput333 net333 VGND VGND VPWR VPWR out2_4[9] sky130_fd_sc_hd__buf_1
Xoutput311 net311 VGND VGND VPWR VPWR out2_2[9] sky130_fd_sc_hd__buf_1
Xoutput322 net322 VGND VGND VPWR VPWR out2_3[9] sky130_fd_sc_hd__buf_1
Xoutput377 net377 VGND VGND VPWR VPWR out2_8[9] sky130_fd_sc_hd__buf_1
Xoutput366 net366 VGND VGND VPWR VPWR out2_7[9] sky130_fd_sc_hd__buf_1
Xoutput355 net355 VGND VGND VPWR VPWR out2_6[9] sky130_fd_sc_hd__buf_1
Xsub_module16_581 VGND VGND VPWR VPWR sub_module16_581/HI out1_4[0] sky130_fd_sc_hd__conb_1
X_2577_ _2229_ _2278_ _2280_ _2281_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__a211o_1
X_4316_ _1449_ _1451_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__a21oi_2
Xoutput399 net399 VGND VGND VPWR VPWR partial_sum14_1[3] sky130_fd_sc_hd__buf_1
Xoutput388 net388 VGND VGND VPWR VPWR partial_sum14[6] sky130_fd_sc_hd__buf_1
X_4247_ _1400_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__nand2_2
X_4178_ _1341_ _1344_ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_58_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3129_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_96_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_67_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_137_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_85_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3480_ _0758_ _0766_ _0771_ _0772_ _0763_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_94_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2500_ net22 net24 _2210_ _2211_ net21 VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__a2111o_2
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2431_ _2149_ _2109_ _2099_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__or3_2
XFILLER_0_51_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5150_ _2105_ net82 _2067_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__mux2_1
X_2362_ _2084_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5081_ _0208_ net49 _2034_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__mux2_1
X_4101_ net122 net109 VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nor2_1
X_4032_ _1212_ net491 VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_125_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4934_ _1938_ _1941_ VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_12 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_129_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4865_ net159 net172 VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_23 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_45 net71 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_56 net197 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4796_ _1813_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__nor2_2
XFILLER_0_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3816_ _2296_ _2272_ _1028_ _2270_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a22oi_4
XANTENNA_34 net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_132_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_89 net554 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_78 net345 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_67 net272 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3747_ _1002_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__nor2_1
X_3678_ _2108_ _0941_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__and2_2
XFILLER_0_88_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2629_ _2257_ _2300_ _2301_ _2255_ _2326_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__a221o_1
Xoutput141 net141 VGND VGND VPWR VPWR final_sum3[6] sky130_fd_sc_hd__buf_1
Xoutput152 net152 VGND VGND VPWR VPWR final_sum4[4] sky130_fd_sc_hd__buf_1
Xoutput130 net130 VGND VGND VPWR VPWR final_sum2[8] sky130_fd_sc_hd__buf_1
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput174 net174 VGND VGND VPWR VPWR final_sum6[12] sky130_fd_sc_hd__buf_1
Xoutput185 net185 VGND VGND VPWR VPWR final_sum7[10] sky130_fd_sc_hd__buf_1
Xoutput163 net163 VGND VGND VPWR VPWR final_sum5[2] sky130_fd_sc_hd__buf_1
Xoutput196 net196 VGND VGND VPWR VPWR final_sum7[9] sky130_fd_sc_hd__buf_1
XFILLER_0_97_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2980_ _0316_ _0327_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4650_ net240 _0446_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__xnor2_4
Xinput21 addr5[0] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_4
Xinput10 addr2[4] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_2
XFILLER_0_116_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3601_ _0878_ _0881_ _0882_ _0803_ _2202_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o32a_1
Xinput32 addr7[1] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
Xinput54 data2[5] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_2
Xinput43 data1[2] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_114_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4581_ net514 _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__xnor2_1
Xinput98 data8[1] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
Xinput87 data6[6] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
Xinput76 data5[3] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_1
Xinput65 data4[0] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
X_3532_ _0822_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_2
X_3463_ _2121_ _0745_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2414_ sm2.s1.t2.A_wire\[6\] _2115_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__or2_1
X_5202_ clknet_3_6__leaf_clk _0038_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5133_ _2227_ net74 _2056_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__mux2_1
X_3394_ _2085_ _0658_ _0697_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__o22a_1
X_5064_ _0650_ net41 _2023_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4015_ _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__inv_2
XFILLER_0_94_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4917_ _1482_ net416 VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4848_ net170 net183 VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4779_ _1035_ _1809_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_55 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_122_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2963_ _0319_ _0322_ _0323_ _0299_ _0325_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__a221o_2
XTAP_TAPCELL_ROW_17_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4702_ _1765_ _1766_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2894_ _0252_ _0243_ _0263_ _0216_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4633_ _1709_ _1712_ VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__xor2_2
XFILLER_0_25_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4564_ net142 net155 VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__xor2_2
X_3515_ _0806_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_77_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4495_ net245 net329 VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__xnor2_2
X_3446_ _0738_ net14 net15 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_110_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3377_ _0683_ _0662_ _0685_ _0659_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5116_ _2057_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_5047_ _0299_ net65 _2012_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3300_ _2131_ _0608_ _0590_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__and3_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4280_ net289 net377 VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__and2_1
X_3231_ _0531_ _0547_ _0554_ _0526_ _0529_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a221o_1
X_3162_ sm2.s2.t1.A_wire\[3\] VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_72_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3093_ _0373_ _0400_ _0411_ _0367_ _2193_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a221o_1
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3995_ _1201_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2946_ net16 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__buf_2
XFILLER_0_72_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2877_ _0226_ _0215_ _0227_ _0233_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o211a_1
X_4616_ net249 net333 VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4547_ _1635_ _1636_ _1639_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_131_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4478_ _1582_ _1583_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3429_ _0732_ VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_2
XFILLER_0_99_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_97_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2800_ _0176_ _0178_ _0181_ _0082_ _2087_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o32a_1
X_3780_ _2296_ _2230_ _1028_ _2227_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a22o_1
X_2731_ _0115_ _0116_ _0121_ _0100_ _0102_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__o32a_1
XFILLER_0_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4401_ _1517_ _1518_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__and2b_1
X_2662_ _2177_ _2270_ _2352_ _2354_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__o22a_2
XFILLER_0_41_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput526 net526 VGND VGND VPWR VPWR sum_out4[8] sky130_fd_sc_hd__buf_1
Xoutput515 net515 VGND VGND VPWR VPWR sum_out3[9] sky130_fd_sc_hd__buf_1
Xoutput504 net504 VGND VGND VPWR VPWR sum_out3[0] sky130_fd_sc_hd__buf_1
X_2593_ net22 VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput559 net559 VGND VGND VPWR VPWR sum_out7[5] sky130_fd_sc_hd__buf_1
Xoutput548 net548 VGND VGND VPWR VPWR sum_out6[6] sky130_fd_sc_hd__buf_1
Xoutput537 net537 VGND VGND VPWR VPWR sum_out5[7] sky130_fd_sc_hd__buf_1
XFILLER_0_112_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4332_ _1466_ _1467_ VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__xor2_2
X_4263_ _1394_ net573 VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3214_ _0535_ _0541_ _0542_ _0543_ _0516_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__o32a_1
XFILLER_0_10_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4194_ _1352_ _1357_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_105_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3145_ _0275_ _0454_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3076_ _0358_ _0396_ _0408_ _0344_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_114_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3978_ _1171_ _1173_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__o21a_2
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2929_ _0280_ _0240_ _0248_ _0275_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_102 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_113 net446 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_132_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput8 addr2[2] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_4
XFILLER_0_127_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4950_ _1951_ _1954_ VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__xor2_2
XFILLER_0_129_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4881_ net160 net173 VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__or2_1
X_3901_ _0233_ _1087_ _1089_ _0231_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__a22o_1
XFILLER_0_117_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3832_ net530 _1074_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_119_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3763_ net259 net344 VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__or2_1
X_3694_ _2156_ _0939_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nor2_1
XFILLER_0_131_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2714_ _0102_ _0083_ _0097_ _0092_ _0106_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a221o_1
X_2645_ _2272_ _2301_ _2332_ _2255_ _2340_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput301 net301 VGND VGND VPWR VPWR out2_2[0] sky130_fd_sc_hd__buf_1
Xoutput334 net334 VGND VGND VPWR VPWR out2_5[0] sky130_fd_sc_hd__buf_1
Xoutput312 net312 VGND VGND VPWR VPWR out2_3[0] sky130_fd_sc_hd__buf_1
Xoutput323 net323 VGND VGND VPWR VPWR out2_4[0] sky130_fd_sc_hd__buf_1
X_4315_ _1448_ net565 VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__and2b_1
Xoutput367 net367 VGND VGND VPWR VPWR out2_8[0] sky130_fd_sc_hd__buf_1
Xoutput356 net356 VGND VGND VPWR VPWR out2_7[0] sky130_fd_sc_hd__buf_1
Xoutput345 net345 VGND VGND VPWR VPWR out2_6[0] sky130_fd_sc_hd__buf_1
XFILLER_0_10_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput378 net378 VGND VGND VPWR VPWR partial_sum14[0] sky130_fd_sc_hd__buf_1
X_2576_ _2234_ _2265_ _2272_ _2242_ _2233_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput389 net389 VGND VGND VPWR VPWR partial_sum14[7] sky130_fd_sc_hd__buf_1
Xsub_module16_582 VGND VGND VPWR VPWR sub_module16_582/HI out1_8[0] sky130_fd_sc_hd__conb_1
X_4246_ net278 net365 VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__nand2_1
X_4177_ _1342_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__nand2_2
XFILLER_0_93_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3128_ _0453_ _0460_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__or2_1
X_3059_ _0347_ _0397_ _0400_ _0326_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_94_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2430_ _2121_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__buf_4
XFILLER_0_51_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2361_ _2083_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__buf_4
XFILLER_0_138_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4100_ net122 net482 _1245_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and3_1
X_5080_ _2038_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4031_ net481 _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_125_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4933_ _1936_ _1939_ _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4864_ _1875_ _1888_ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_13 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4795_ _1802_ _1805_ _1814_ _1816_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__o211a_1
XANTENNA_46 net79 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_57 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3815_ net538 _1056_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__and2_1
XANTENNA_35 net53 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_132_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_79 net348 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_68 net277 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3746_ net256 net341 VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3677_ _2108_ _0941_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__and2b_2
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2628_ _2309_ _2307_ _2239_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__and3b_1
Xoutput131 net131 VGND VGND VPWR VPWR final_sum2[9] sky130_fd_sc_hd__buf_1
Xoutput142 net142 VGND VGND VPWR VPWR final_sum3[7] sky130_fd_sc_hd__buf_1
Xoutput120 net120 VGND VGND VPWR VPWR final_sum2[10] sky130_fd_sc_hd__buf_1
Xoutput175 net175 VGND VGND VPWR VPWR final_sum6[1] sky130_fd_sc_hd__buf_1
Xoutput186 net186 VGND VGND VPWR VPWR final_sum7[11] sky130_fd_sc_hd__buf_1
Xoutput164 net164 VGND VGND VPWR VPWR final_sum5[3] sky130_fd_sc_hd__buf_1
Xoutput153 net153 VGND VGND VPWR VPWR final_sum4[5] sky130_fd_sc_hd__buf_1
X_2559_ _2229_ _2265_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__and2_1
Xoutput197 net197 VGND VGND VPWR VPWR final_sum8[0] sky130_fd_sc_hd__buf_1
X_4229_ net560 _1364_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_124_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput22 addr5[1] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_4
Xinput11 addr3[0] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
X_3600_ _0807_ _0847_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__and2_1
X_4580_ _0742_ _0796_ _1532_ _0793_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__a22o_1
Xinput33 addr7[2] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
Xinput55 data2[6] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_2
Xinput44 data1[3] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_2
X_3531_ _2089_ _0764_ _0737_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput88 data6[7] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
Xinput77 data5[4] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_1
Xinput66 data4[1] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_1
Xinput99 data8[2] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
X_3462_ _0756_ _0758_ _0761_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__a21o_2
XFILLER_0_110_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2413_ _2118_ _2128_ _2130_ _2105_ _2132_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__a221o_1
X_5201_ clknet_3_6__leaf_clk _0037_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
X_3393_ _0659_ _0698_ _0699_ _0657_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a221o_1
XFILLER_0_58_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5132_ _2065_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5063_ _2029_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_4014_ _1218_ _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4916_ _1924_ _1927_ VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__xor2_1
XFILLER_0_117_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4847_ net170 net183 VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4778_ _1815_ _1817_ VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__xnor2_4
X_3729_ _2315_ _2321_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2962_ _0320_ _0317_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_17_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4701_ net382 net396 VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4632_ _1660_ _1710_ _1711_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__a21o_1
X_2893_ _0260_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and2_2
XFILLER_0_127_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4563_ _1649_ _1653_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__xor2_4
X_3514_ _0803_ _0807_ _0794_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_77_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4494_ _1570_ _1571_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__a21o_2
X_3445_ net11 _0738_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3376_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__buf_2
X_5115_ _2357_ net97 _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__mux2_1
X_5046_ _2020_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_109_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_383 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3230_ _0557_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_72_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3161_ _0494_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__inv_2
X_3092_ _0375_ _0405_ _0408_ _0366_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3994_ _0275_ _1087_ _1089_ _0270_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_57_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2945_ _0300_ net19 net20 VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2876_ _2131_ _0226_ _0220_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__and3_2
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4615_ _0305_ _0367_ _1539_ _0366_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__a22oi_4
X_4546_ _1635_ _1636_ _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__a21oi_2
X_4477_ net235 net318 VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3428_ _0727_ _0729_ _0731_ _0703_ _2202_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o32a_1
X_3359_ _0649_ net2 VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nor2_2
X_5029_ rst VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_137_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2730_ _0117_ _0083_ _0084_ _0120_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2661_ _2279_ _2329_ _2332_ _2278_ _2353_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4400_ net232 _0842_ _0843_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__nand3b_1
Xoutput527 net527 VGND VGND VPWR VPWR sum_out4[9] sky130_fd_sc_hd__buf_1
Xoutput516 net516 VGND VGND VPWR VPWR sum_out4[0] sky130_fd_sc_hd__buf_1
Xoutput505 net505 VGND VGND VPWR VPWR sum_out3[10] sky130_fd_sc_hd__buf_1
X_2592_ net22 _2292_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_74_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput549 net549 VGND VGND VPWR VPWR sum_out6[7] sky130_fd_sc_hd__buf_1
Xoutput538 net538 VGND VGND VPWR VPWR sum_out5[8] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4331_ net188 net201 _1463_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4262_ net574 _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__xor2_4
XFILLER_0_66_10 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3213_ _2085_ _0515_ _0511_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21o_2
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4193_ _1353_ net571 VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3144_ _0481_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_4
X_3075_ _0337_ _0413_ _0397_ _0361_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_85_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3977_ net299 net218 VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2928_ _0224_ _0215_ _0289_ _2193_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2859_ sm1.s1.t2.A_wire\[3\] sm1.s1.t2.A_wire\[4\] _0231_ VGND VGND VPWR VPWR _0232_
+ sky130_fd_sc_hd__o21ai_1
XFILLER_0_130_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4529_ _1623_ _1626_ VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__xor2_4
XFILLER_0_130_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_114 net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_103 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_68_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 addr2[3] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
X_3900_ _1124_ VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__buf_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4880_ _1898_ _1899_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__nor2_2
XFILLER_0_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3831_ _1070_ _1071_ _1068_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_80_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3762_ _1015_ _1016_ VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_119_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3693_ _2140_ _0942_ _0951_ _2118_ _0949_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a221o_1
X_2713_ _0085_ _0089_ _0105_ _0084_ _0088_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a221o_1
X_2644_ _2257_ _2309_ _2307_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__and3_1
Xoutput335 net335 VGND VGND VPWR VPWR out2_5[10] sky130_fd_sc_hd__buf_1
Xoutput324 net324 VGND VGND VPWR VPWR out2_4[10] sky130_fd_sc_hd__buf_1
XFILLER_0_2_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput302 net302 VGND VGND VPWR VPWR out2_2[10] sky130_fd_sc_hd__buf_1
X_2575_ _2279_ _2228_ _2240_ _2270_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__a22o_1
Xoutput313 net313 VGND VGND VPWR VPWR out2_3[10] sky130_fd_sc_hd__buf_1
X_4314_ _1455_ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput368 net368 VGND VGND VPWR VPWR out2_8[10] sky130_fd_sc_hd__buf_1
Xoutput357 net357 VGND VGND VPWR VPWR out2_7[10] sky130_fd_sc_hd__buf_1
Xoutput346 net346 VGND VGND VPWR VPWR out2_6[10] sky130_fd_sc_hd__buf_1
XFILLER_0_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput379 net379 VGND VGND VPWR VPWR partial_sum14[10] sky130_fd_sc_hd__buf_1
Xsub_module16_583 VGND VGND VPWR VPWR sub_module16_583/HI out1_5[0] sky130_fd_sc_hd__conb_1
X_4245_ net278 net365 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4176_ _1323_ _1324_ _1326_ _1322_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3127_ _0467_ VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_93_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3058_ _0344_ _0396_ _0408_ _0319_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2360_ net105 VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_9_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ _0724_ _1094_ _1096_ _0718_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__a22o_2
XFILLER_0_47_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4932_ _1493_ _1872_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4863_ net159 net172 VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__xnor2_1
XANTENNA_14 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_25 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4794_ net352 net266 VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__xnor2_4
XANTENNA_47 net80 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3814_ _1060_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__inv_2
XANTENNA_36 net54 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_58 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_69 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3745_ net256 net341 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net110 VGND VGND VPWR VPWR final_sum1[1] sky130_fd_sc_hd__buf_1
X_3676_ _0944_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__inv_2
XFILLER_0_42_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2627_ _2247_ _2324_ _2313_ _2249_ _2172_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__a221o_1
Xoutput143 net143 VGND VGND VPWR VPWR final_sum3[8] sky130_fd_sc_hd__buf_1
Xoutput121 net121 VGND VGND VPWR VPWR final_sum2[11] sky130_fd_sc_hd__buf_1
Xoutput132 net132 VGND VGND VPWR VPWR final_sum3[0] sky130_fd_sc_hd__buf_1
X_2558_ _2263_ _2264_ VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__and2_2
Xoutput176 net176 VGND VGND VPWR VPWR final_sum6[2] sky130_fd_sc_hd__buf_1
Xoutput165 net165 VGND VGND VPWR VPWR final_sum5[4] sky130_fd_sc_hd__buf_1
Xoutput154 net154 VGND VGND VPWR VPWR final_sum4[6] sky130_fd_sc_hd__buf_1
X_2489_ _2147_ _2200_ _2201_ _2202_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput187 net187 VGND VGND VPWR VPWR final_sum7[12] sky130_fd_sc_hd__buf_1
Xoutput198 net198 VGND VGND VPWR VPWR final_sum8[10] sky130_fd_sc_hd__buf_1
X_4228_ _1384_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4159_ _1311_ _0517_ _1313_ _0516_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__a22o_1
XFILLER_0_97_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput12 addr3[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput34 addr7[3] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_2
Xinput23 addr5[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_2
Xinput45 data1[4] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_2
X_3530_ _0821_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_2
XFILLER_0_3_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput89 data7[0] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_1
Xinput78 data5[5] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_1
Xinput67 data4[2] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
Xinput56 data2[7] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_2
XFILLER_0_24_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3461_ _0757_ _0759_ _0760_ _0737_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2412_ _2131_ _2092_ _2129_ _2099_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__and4_1
X_5200_ clknet_3_6__leaf_clk _0036_ VGND VGND VPWR VPWR sm2.s2.t1.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_3392_ _0668_ _0681_ _0685_ _0677_ _2122_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a221o_1
X_5131_ _2208_ net73 _2056_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__mux2_1
X_5062_ _0373_ net72 _2023_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__mux2_1
X_4013_ _0298_ _0494_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4915_ _1925_ _1923_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4846_ _1872_ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__inv_2
XFILLER_0_62_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4777_ _1802_ _1805_ _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_43_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3728_ _2244_ net338 VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3659_ _0723_ _0922_ _0904_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_451 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2961_ sm1.s2.t2.A_wire\[3\] sm1.s2.t2.A_wire\[4\] VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_17_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4700_ net382 net396 VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4631_ net390 net404 VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__and2_1
X_2892_ _0252_ _0245_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_114_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4562_ _1650_ net525 VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__xor2_4
X_3513_ sm1.s2.t1.A_wire\[10\] VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_77_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4493_ net244 net328 VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3444_ net15 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_133_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3375_ _2093_ _0669_ _0656_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__and3_1
X_5114_ _2011_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__buf_4
X_5045_ _0807_ net64 _2012_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__mux2_1
XFILLER_0_109_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4829_ _1856_ _1858_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_35_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_395 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3160_ _0280_ _0469_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21ai_4
X_3091_ _0361_ _0413_ _0397_ _0384_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3993_ net502 _1184_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__and2_1
X_2944_ net16 _0302_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2875_ _0245_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__and2_2
XFILLER_0_72_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4614_ _1662_ _1682_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__a21o_2
X_4545_ _1637_ _1638_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4476_ net235 net318 VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3427_ _0694_ _0724_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3358_ sm1.s1.t1.A_wire\[5\] VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__buf_2
X_3289_ _2110_ sm2.s2.t1.A_wire\[3\] _0608_ _0591_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and4_1
X_5028_ _1882_ VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__inv_2
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2660_ _2272_ _2328_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput517 net517 VGND VGND VPWR VPWR sum_out4[10] sky130_fd_sc_hd__buf_1
Xoutput506 net506 VGND VGND VPWR VPWR sum_out3[11] sky130_fd_sc_hd__buf_1
X_2591_ _2211_ net25 VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput539 net539 VGND VGND VPWR VPWR sum_out5[9] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput528 net528 VGND VGND VPWR VPWR sum_out5[0] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_74_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4330_ _1303_ _1308_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__xor2_2
X_4261_ _1315_ _0120_ _1317_ _0117_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a22o_2
XFILLER_0_10_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3212_ _0499_ _0522_ _0518_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4192_ _1355_ _1356_ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__xor2_4
X_3143_ _0239_ _0469_ _0478_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__o22a_1
X_3074_ _0352_ _0400_ _0405_ _0353_ _2187_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3976_ _1188_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__inv_2
XFILLER_0_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2927_ _0276_ _0285_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2858_ sm1.s1.t2.A_wire\[5\] VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_28_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2789_ _2149_ _0171_ _0153_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__or3_1
XFILLER_0_115_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4528_ _1598_ _1624_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__a21o_1
X_4459_ _1558_ _1569_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_37_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_115 net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_104 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_322 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_46_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_55_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3830_ _1073_ VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkinv_4
XFILLER_0_116_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3761_ _1013_ _1010_ _1014_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2712_ _0103_ _0104_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_119_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3692_ _0958_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_4
X_2643_ _2261_ _2324_ _2313_ _2265_ _2144_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__a221o_1
X_2574_ sm2.s1.t1.A_wire\[10\] VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__buf_2
XFILLER_0_77_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput303 net303 VGND VGND VPWR VPWR out2_2[1] sky130_fd_sc_hd__buf_1
Xoutput314 net314 VGND VGND VPWR VPWR out2_3[1] sky130_fd_sc_hd__buf_1
Xoutput325 net325 VGND VGND VPWR VPWR out2_4[1] sky130_fd_sc_hd__buf_1
X_4313_ _1444_ _1445_ _1446_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o21a_1
Xoutput369 net369 VGND VGND VPWR VPWR out2_8[1] sky130_fd_sc_hd__buf_1
Xoutput358 net358 VGND VGND VPWR VPWR out2_7[1] sky130_fd_sc_hd__buf_1
Xoutput347 net347 VGND VGND VPWR VPWR out2_6[1] sky130_fd_sc_hd__buf_1
Xoutput336 net336 VGND VGND VPWR VPWR out2_5[1] sky130_fd_sc_hd__buf_1
XFILLER_0_10_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4244_ _1393_ _1399_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_91_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4175_ net274 net361 VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3126_ _0462_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3057_ _2172_ _0313_ _0395_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__nor3_4
XFILLER_0_26_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3959_ _1173_ _1174_ VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__nor2_4
XFILLER_0_18_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_63_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_69_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_125_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_72_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4931_ _1493_ _1872_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__nand2_1
X_4862_ _1884_ _1887_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__xnor2_4
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3813_ _1058_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__or2_4
XANTENNA_15 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_48 net90 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4793_ _1822_ _1828_ _1829_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__a21o_2
XFILLER_0_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_37 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_59 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3744_ _1000_ _1001_ VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__nand2_2
X_3675_ _2124_ _0939_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__o21a_4
XFILLER_0_88_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2626_ _2309_ _2305_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_136_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput133 net133 VGND VGND VPWR VPWR final_sum3[10] sky130_fd_sc_hd__buf_1
Xoutput122 net122 VGND VGND VPWR VPWR final_sum2[12] sky130_fd_sc_hd__buf_1
Xoutput111 net111 VGND VGND VPWR VPWR final_sum1[2] sky130_fd_sc_hd__buf_1
XFILLER_0_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2557_ _2257_ _2246_ _2261_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__o21ai_1
Xoutput177 net177 VGND VGND VPWR VPWR final_sum6[3] sky130_fd_sc_hd__buf_1
Xoutput166 net166 VGND VGND VPWR VPWR final_sum5[5] sky130_fd_sc_hd__buf_1
XFILLER_0_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput155 net155 VGND VGND VPWR VPWR final_sum4[7] sky130_fd_sc_hd__buf_1
Xoutput144 net144 VGND VGND VPWR VPWR final_sum3[9] sky130_fd_sc_hd__buf_1
X_2488_ _2177_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__buf_6
Xoutput188 net188 VGND VGND VPWR VPWR final_sum7[1] sky130_fd_sc_hd__buf_1
Xoutput199 net199 VGND VGND VPWR VPWR final_sum8[11] sky130_fd_sc_hd__buf_1
X_4227_ net561 _1383_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__or2_1
X_4158_ _1322_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__xnor2_4
X_4089_ _1275_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__xnor2_4
X_3109_ net10 net8 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 addr3[2] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
Xinput35 addr7[4] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_2
Xinput24 addr5[3] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_2
Xinput46 data1[5] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_2
XFILLER_0_24_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput79 data5[6] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput68 data4[3] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_1
Xinput57 data3[0] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3460_ _0744_ _0750_ _2121_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21oi_2
X_2411_ _2101_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__buf_4
XFILLER_0_20_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3391_ sm1.s1.t1.A_wire\[7\] _0688_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__xor2_4
X_5130_ _2064_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5061_ _2028_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
X_4012_ _0298_ _0494_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4914_ net429 net415 VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4845_ _1866_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__xor2_4
XFILLER_0_23_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4776_ net350 net264 VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3727_ _0986_ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__inv_2
XFILLER_0_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3658_ _0930_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_30_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3589_ _0869_ _0870_ _0872_ _0787_ _2087_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__o32a_1
X_2609_ _2299_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__buf_2
XFILLER_0_11_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5259_ net202 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_3_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2960_ _0307_ _0312_ _2122_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2891_ sm1.s1.t2.A_wire\[8\] VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__buf_2
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4630_ net390 net404 VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4561_ _1651_ _1652_ VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__xor2_4
XFILLER_0_52_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3512_ sm1.s2.t1.A_wire\[9\] _0794_ sm1.s2.t1.A_wire\[10\] VGND VGND VPWR VPWR _0806_
+ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_77_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4492_ _0305_ _0337_ _1539_ _0326_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3443_ _0739_ _0740_ _0742_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_100_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5113_ _2055_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3374_ sm1.s1.t1.A_wire\[6\] VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__clkbuf_4
X_5044_ _2019_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4828_ _1845_ _1847_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4759_ net545 _1797_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_99_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3090_ _0436_ VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__inv_2
XFILLER_0_55_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3992_ _1201_ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__inv_2
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2943_ _0301_ _0303_ _0305_ _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2874_ _0239_ _0230_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4613_ _1671_ _1681_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4544_ net237 net320 VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4475_ net234 net317 VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3426_ _0719_ _0681_ _0709_ _0673_ _2188_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a221o_1
X_3357_ _0658_ _0665_ _0661_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__and4_1
X_3288_ _0501_ _0497_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nor2_1
X_5027_ _1806_ VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__inv_2
XFILLER_0_138_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput518 net518 VGND VGND VPWR VPWR sum_out4[11] sky130_fd_sc_hd__buf_1
Xoutput507 net507 VGND VGND VPWR VPWR sum_out3[1] sky130_fd_sc_hd__buf_1
X_2590_ net21 VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_74_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput529 net529 VGND VGND VPWR VPWR sum_out5[10] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4260_ _1411_ _1412_ VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__xor2_4
X_4191_ _0114_ _0187_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__xor2_2
X_3211_ _0515_ _0513_ _0539_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a31o_1
X_3142_ _0255_ _0463_ _0464_ _0252_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a221o_1
X_3073_ _0347_ _0411_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_85_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3975_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_17_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2926_ _2177_ _0261_ _0291_ _0292_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__o22a_2
XFILLER_0_122_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2857_ sm1.s1.t2.A_wire\[3\] sm1.s1.t2.A_wire\[4\] sm1.s1.t2.A_wire\[5\] VGND VGND
+ VPWR VPWR _0230_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2788_ _0075_ _0151_ _0145_ _0152_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__a211o_1
XFILLER_0_103_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4527_ net245 net329 VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__and2_1
XFILLER_0_111_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4458_ _1567_ _1568_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__or2b_2
X_3409_ sm1.s1.t1.A_wire\[9\] _0707_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xor2_4
X_4389_ _1294_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_105 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_116 net553 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_95_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_138_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_101_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3760_ _1013_ _1010_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__a21oi_1
X_2711_ _0102_ _0091_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_119_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3691_ _2105_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__mux2_1
X_2642_ _2270_ _2300_ _2328_ _2249_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__a22o_1
X_2573_ _2276_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__nor2_2
XFILLER_0_72_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput304 net304 VGND VGND VPWR VPWR out2_2[2] sky130_fd_sc_hd__buf_1
Xoutput315 net315 VGND VGND VPWR VPWR out2_3[2] sky130_fd_sc_hd__buf_1
Xoutput326 net326 VGND VGND VPWR VPWR out2_4[2] sky130_fd_sc_hd__buf_1
Xoutput359 net359 VGND VGND VPWR VPWR out2_7[2] sky130_fd_sc_hd__buf_1
XFILLER_0_77_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput348 net348 VGND VGND VPWR VPWR out2_6[2] sky130_fd_sc_hd__buf_1
Xoutput337 net337 VGND VGND VPWR VPWR out2_5[2] sky130_fd_sc_hd__buf_1
X_4312_ net554 _1454_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__xnor2_2
X_4243_ _1394_ net573 VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__xor2_4
XFILLER_0_10_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4174_ _1339_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__or2_2
X_3125_ _0218_ _0463_ _0464_ _0217_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__a221o_1
XFILLER_0_89_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3056_ _0407_ VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__inv_2
XFILLER_0_89_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3958_ _1150_ _1154_ _1172_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_21_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3889_ _0659_ _1094_ _1096_ _0658_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a22oi_4
X_2909_ _0247_ _0248_ _0275_ _0216_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a221o_1
XFILLER_0_60_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4930_ net421 net407 VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__xnor2_1
X_4861_ _1885_ _1870_ _1886_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__a21o_2
XFILLER_0_86_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3812_ _1055_ _1052_ _1057_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__and3_1
XANTENNA_16 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4792_ net547 _1823_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__and2_1
XANTENNA_27 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_38 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_49 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3743_ _0995_ _0996_ _0999_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_55_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3674_ _2090_ _0941_ _0942_ _2105_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_88_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2625_ _2323_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_70_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput134 net134 VGND VGND VPWR VPWR final_sum3[11] sky130_fd_sc_hd__buf_1
Xoutput123 net123 VGND VGND VPWR VPWR final_sum2[1] sky130_fd_sc_hd__buf_1
Xoutput112 net112 VGND VGND VPWR VPWR final_sum1[3] sky130_fd_sc_hd__buf_1
X_2556_ sm2.s1.t1.A_wire\[7\] sm2.s1.t1.A_wire\[8\] _2246_ VGND VGND VPWR VPWR _2263_
+ sky130_fd_sc_hd__or3_1
Xoutput167 net167 VGND VGND VPWR VPWR final_sum5[6] sky130_fd_sc_hd__buf_1
XFILLER_0_10_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput156 net156 VGND VGND VPWR VPWR final_sum4[8] sky130_fd_sc_hd__buf_1
Xoutput145 net145 VGND VGND VPWR VPWR final_sum4[0] sky130_fd_sc_hd__buf_1
X_2487_ _2129_ _2103_ _2182_ _2180_ _2150_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__o32a_1
Xoutput178 net178 VGND VGND VPWR VPWR final_sum6[4] sky130_fd_sc_hd__buf_1
Xoutput189 net189 VGND VGND VPWR VPWR final_sum7[2] sky130_fd_sc_hd__buf_1
X_4226_ net561 _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__nand2_1
X_4157_ _1323_ _1324_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__and3_1
X_3108_ net6 net7 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__xnor2_1
X_4088_ _1272_ _1274_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a21oi_2
X_3039_ net16 _0302_ net17 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__or3b_1
XFILLER_0_77_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput25 addr5[4] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_4
Xinput14 addr3[3] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput36 addr8[0] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
XFILLER_0_107_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput69 data4[4] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_1
Xinput58 data3[1] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 data1[6] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_2
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2410_ _2094_ _2129_ _2109_ _2103_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__and4_2
XFILLER_0_24_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3390_ _2122_ _0665_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__nor2_2
XFILLER_0_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5060_ _0366_ net71 _2023_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__mux2_1
X_4011_ _1201_ _1203_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4913_ net429 net415 VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4844_ net170 net183 VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4775_ _1813_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__or2b_2
XFILLER_0_23_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3726_ _0981_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3657_ _0703_ _0904_ _0927_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o22a_1
XFILLER_0_113_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3588_ _0796_ _0844_ _0849_ _0789_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__a221o_1
X_2608_ _2227_ _2299_ _2305_ _2307_ _2208_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__a32o_1
X_2539_ _2247_ _2236_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5258_ net201 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__buf_1
X_4209_ _1353_ net571 VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__and2_1
X_5189_ clknet_3_3__leaf_clk _0025_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_109_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2890_ sm1.s1.t2.A_wire\[7\] sm1.s1.t2.A_wire\[8\] _0245_ VGND VGND VPWR VPWR _0260_
+ sky130_fd_sc_hd__or3_1
XFILLER_0_71_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4560_ _1623_ _1626_ _1622_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__a21o_2
XFILLER_0_107_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3511_ _0805_ VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_77_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4491_ _1540_ net521 _1573_ _1572_ net522 VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__a32o_2
X_3442_ net13 VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__inv_2
XFILLER_0_100_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3373_ _0650_ _0680_ _0681_ _0658_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5112_ _0571_ net96 _2045_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5043_ _0803_ net63 _2012_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4827_ _1846_ net549 VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4758_ _1800_ VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__inv_2
X_3709_ _2186_ _0942_ _0945_ _2168_ _0949_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_99_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4689_ net135 net148 VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_412 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3991_ _1199_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__xor2_4
X_2942_ _0302_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2873_ sm1.s1.t2.A_wire\[6\] _0230_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__or2_2
X_4612_ _1695_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_115_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4543_ net237 net320 VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4474_ _1579_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3425_ _0718_ _0687_ _0728_ _0657_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a22o_1
X_3356_ net105 _0652_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and2_1
X_3287_ _0524_ _0603_ _0605_ _0517_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5026_ _1859_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__inv_2
XFILLER_0_136_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_106_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_432 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput508 net508 VGND VGND VPWR VPWR sum_out3[2] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput519 net519 VGND VGND VPWR VPWR sum_out4[1] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_74_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4190_ _1334_ _1335_ _1354_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__a21o_2
X_3210_ _0537_ _0519_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3141_ _0260_ _0262_ _0454_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__and3_1
X_3072_ _0421_ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3974_ _1178_ _1179_ _1185_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__or3b_1
XFILLER_0_134_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2925_ _0248_ _0263_ _0285_ _0257_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2856_ _0217_ _0225_ _0220_ _0227_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2787_ _0085_ _0166_ _0167_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_103_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4526_ net245 net329 VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4457_ _1564_ _1565_ _1566_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3408_ _0703_ _0687_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a21o_1
X_4388_ _1507_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__nand2_1
X_3339_ _2088_ _0649_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5009_ _1997_ _1999_ VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__xor2_1
XANTENNA_106 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_117 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_138_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2710_ sm2.s2.t2.A_wire\[6\] _0091_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_119_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3690_ _2108_ _2085_ _0937_ _0941_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a211o_2
XFILLER_0_42_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2641_ _2337_ VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_124_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2572_ sm2.s1.t1.A_wire\[10\] _2269_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__and2_1
Xoutput305 net305 VGND VGND VPWR VPWR out2_2[3] sky130_fd_sc_hd__buf_1
Xoutput316 net316 VGND VGND VPWR VPWR out2_3[3] sky130_fd_sc_hd__buf_1
X_4311_ _1442_ _1443_ _1440_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__o21a_2
XFILLER_0_77_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput349 net349 VGND VGND VPWR VPWR out2_6[3] sky130_fd_sc_hd__buf_1
Xoutput338 net338 VGND VGND VPWR VPWR out2_5[3] sky130_fd_sc_hd__buf_1
Xoutput327 net327 VGND VGND VPWR VPWR out2_4[3] sky130_fd_sc_hd__buf_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4242_ _1397_ _1398_ VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_91_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4173_ net275 net362 VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__nor2_1
X_3124_ _0233_ _0454_ _0455_ _0231_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a22o_1
X_3055_ _0404_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3957_ _1150_ _1154_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2908_ _0252_ _0240_ _0276_ _0255_ _2144_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a221o_1
XFILLER_0_18_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3888_ _1111_ _1114_ VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__xor2_4
XFILLER_0_33_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2839_ net7 net6 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__or2b_2
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4509_ _1585_ _1586_ VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_29_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4860_ _1867_ net551 VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and2b_1
XFILLER_0_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3811_ _1055_ _1052_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_117_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4791_ net547 _1823_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__or2_1
XANTENNA_28 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_39 net56 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_17 net45 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3742_ _0995_ _0996_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3673_ _2108_ _0937_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_70_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2624_ _2315_ _2321_ _2322_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_136_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput124 net124 VGND VGND VPWR VPWR final_sum2[2] sky130_fd_sc_hd__buf_1
Xoutput113 net113 VGND VGND VPWR VPWR final_sum1[4] sky130_fd_sc_hd__buf_1
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_120_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput168 net168 VGND VGND VPWR VPWR final_sum5[7] sky130_fd_sc_hd__buf_1
XFILLER_0_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput157 net157 VGND VGND VPWR VPWR final_sum4[9] sky130_fd_sc_hd__buf_1
Xoutput135 net135 VGND VGND VPWR VPWR final_sum3[12] sky130_fd_sc_hd__buf_1
Xoutput146 net146 VGND VGND VPWR VPWR final_sum4[10] sky130_fd_sc_hd__buf_1
X_2555_ _2261_ _2228_ _2240_ _2257_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__a22o_1
X_2486_ _2182_ _2183_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__or2_1
Xoutput179 net179 VGND VGND VPWR VPWR final_sum6[5] sky130_fd_sc_hd__buf_1
X_4225_ _1311_ _0547_ _1313_ _0546_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4156_ _0514_ _0596_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__or3_1
XFILLER_0_128_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3107_ _0449_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
X_4087_ _1188_ _1196_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__nor2_1
X_3038_ net16 net17 net20 net18 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__or4b_1
XFILLER_0_77_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4989_ _1983_ _1984_ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_257 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 addr8[1] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_4
Xinput26 addr6[0] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_2
Xinput15 addr3[4] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_107_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput59 data3[2] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput48 data1[7] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_2
XFILLER_0_122_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4010_ _1213_ _1216_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__xor2_4
XFILLER_0_79_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4912_ _1482_ net416 VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4843_ _1868_ _1870_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_138_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4774_ net351 net265 VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3725_ _0982_ _0983_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3656_ _0709_ _0910_ _0898_ _0715_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a221o_1
X_3587_ _0801_ _0838_ _0839_ _0803_ _2172_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__a221o_1
X_2607_ _2213_ _2211_ _2306_ _2221_ _2101_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__o311a_2
XFILLER_0_11_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2538_ sm2.s1.t1.A_wire\[6\] VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5257_ net197 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__buf_1
X_2469_ _2150_ _2156_ _2184_ _2100_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__a2bb2o_1
X_4208_ _1353_ net571 VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__or2_1
X_5188_ clknet_3_3__leaf_clk _0024_ VGND VGND VPWR VPWR sm1.s1.t2.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_3_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4139_ net34 _0499_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_45_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3510_ _0800_ _0802_ _0804_ _0777_ _0787_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__o32a_1
XFILLER_0_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4490_ _1594_ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__clkbuf_2
X_3441_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_133_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3372_ _2101_ _0669_ _0665_ _0661_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__and4_2
X_5111_ _2054_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_109_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5042_ _2018_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4826_ net550 _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__xor2_4
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4757_ _1792_ _1799_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3708_ _2200_ _0939_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_99_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4688_ _1756_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_1
XFILLER_0_43_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3639_ _0699_ _0889_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3990_ _1182_ _1183_ _1181_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21a_2
X_2941_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__buf_4
XFILLER_0_71_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4611_ _1693_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__and2_2
X_2872_ _0231_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__and2_1
X_4542_ _1581_ _1564_ _1583_ _1611_ _1582_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__a311o_1
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4473_ _0742_ _0771_ _1532_ _0769_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3424_ _0723_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3355_ net5 _0649_ net2 net3 VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or4_4
X_3286_ _2110_ _0501_ _0537_ _0591_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and4_1
XFILLER_0_29_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5025_ _1809_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4809_ _1048_ net180 VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput509 net509 VGND VGND VPWR VPWR sum_out3[3] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_117_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _0261_ _0455_ _0459_ _0247_ _0461_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a221o_1
X_3071_ _2086_ _0319_ _0419_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__o22a_1
XFILLER_0_106_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3973_ _1178_ _1179_ _1185_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2924_ _0280_ _0243_ _0276_ _0275_ _0290_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__a221o_1
XFILLER_0_127_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2855_ _0226_ _0215_ _0218_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o211a_1
XFILLER_0_115_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2786_ _2149_ _0153_ _0163_ _0079_ _0082_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_96_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4525_ _1621_ _1622_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__nor2_2
XFILLER_0_40_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4456_ _1564_ _1565_ _1566_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4387_ net323 net312 VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__or2_1
X_3407_ sm1.s1.t1.A_wire\[9\] _0662_ _0694_ _0709_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a22o_1
X_3338_ sm1.s1.t1.A_wire\[3\] VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__buf_2
X_3269_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__buf_2
XFILLER_0_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5008_ _1995_ _1996_ _1998_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__a21o_1
XANTENNA_107 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_118 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_129_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2640_ _2334_ _2335_ _2336_ _2237_ _2086_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__o32a_1
XFILLER_0_54_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2571_ sm2.s1.t1.A_wire\[10\] _2269_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput306 net306 VGND VGND VPWR VPWR out2_2[4] sky130_fd_sc_hd__buf_1
Xoutput317 net317 VGND VGND VPWR VPWR out2_3[4] sky130_fd_sc_hd__buf_1
X_4310_ _1437_ _1452_ _1453_ VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__a21oi_4
Xoutput339 net339 VGND VGND VPWR VPWR out2_5[4] sky130_fd_sc_hd__buf_1
Xoutput328 net328 VGND VGND VPWR VPWR out2_4[4] sky130_fd_sc_hd__buf_1
X_4241_ _1372_ _1376_ _1373_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_77_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsub_module16_576 VGND VGND VPWR VPWR sub_module16_576/HI out1_6[0] sky130_fd_sc_hd__conb_1
X_4172_ net275 net362 VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_91_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3123_ _0210_ _0453_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nor2b_2
XPHY_EDGE_ROW_42_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3054_ _0326_ _0396_ _0405_ _0324_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3956_ _1170_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__or2_2
XFILLER_0_9_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2907_ _0215_ _0236_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3887_ _1112_ _1092_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a21oi_4
XPHY_EDGE_ROW_51_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2838_ _0210_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__nor2_4
X_2769_ _2149_ _0153_ _0148_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o21a_2
XFILLER_0_41_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4508_ _1593_ _1607_ _1608_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__a21o_1
X_4439_ _1548_ _1549_ _1537_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4790_ _1819_ _1825_ _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__a21o_1
X_3810_ net538 _1056_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3741_ _0997_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_29 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_18 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3672_ _2095_ _2097_ _0936_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__o31a_2
XFILLER_0_70_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2623_ _2144_ _2208_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2554_ sm2.s1.t1.A_wire\[8\] VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__buf_2
Xoutput125 net125 VGND VGND VPWR VPWR final_sum2[3] sky130_fd_sc_hd__buf_1
Xoutput114 net114 VGND VGND VPWR VPWR final_sum1[5] sky130_fd_sc_hd__buf_1
XFILLER_0_23_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput136 net136 VGND VGND VPWR VPWR final_sum3[1] sky130_fd_sc_hd__buf_1
Xoutput158 net158 VGND VGND VPWR VPWR final_sum5[0] sky130_fd_sc_hd__buf_1
Xoutput147 net147 VGND VGND VPWR VPWR final_sum4[11] sky130_fd_sc_hd__buf_1
XFILLER_0_2_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2485_ _2186_ _2130_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__nand2_1
Xoutput169 net169 VGND VGND VPWR VPWR final_sum5[8] sky130_fd_sc_hd__buf_1
X_4224_ _1381_ _1382_ VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__nor2_2
X_4155_ _0607_ _0612_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__nor2_1
X_3106_ _0208_ _0219_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4086_ net131 net118 VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__xnor2_2
X_3037_ _0302_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4988_ _1977_ _1980_ _1976_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3939_ net488 _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__xor2_4
XFILLER_0_18_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 addr6[1] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_2
Xinput16 addr4[0] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput38 addr8[2] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput49 data2[0] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_2
XFILLER_0_107_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4911_ _1920_ _1923_ VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4842_ _1856_ _1858_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4773_ net351 net265 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_31_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_138_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3724_ _2232_ net337 VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3655_ _0718_ _0890_ _0896_ _0719_ _0909_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__a221o_1
XFILLER_0_130_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2606_ _2294_ _2210_ _2211_ _2213_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_30_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3586_ _0807_ _0832_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2537_ sm2.s1.t1.A_wire\[3\] sm2.s1.t1.A_wire\[4\] sm2.s1.t1.A_wire\[5\] sm2.s1.t1.A_wire\[6\]
+ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__or4_4
X_2468_ _2182_ _2183_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__nor2_2
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5256_ net189 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_2
X_4207_ _1365_ _1368_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__xnor2_4
X_2399_ net105 VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5187_ clknet_3_0__leaf_clk _0023_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
X_4138_ net34 _0499_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_39_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4069_ _1109_ _1117_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_111_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_127_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3440_ net14 net15 VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3371_ _2085_ _0665_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nand2_1
X_5110_ _0560_ net95 _2045_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__mux2_1
X_5041_ _0793_ net62 _2012_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4825_ _2161_ _1794_ _1796_ _2155_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__a22o_2
XFILLER_0_7_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4756_ net164 _1798_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3707_ _0970_ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_99_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4687_ net518 _1745_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3638_ _0690_ _0898_ _0896_ _0683_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3569_ _0789_ _0834_ _0847_ _0769_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5239_ net119 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2940_ net19 net20 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2871_ _0225_ _0220_ _0227_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__and3_2
X_4610_ _1685_ _1669_ _1692_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4541_ net236 net319 VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4472_ _1578_ VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__inv_2
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3423_ _0685_ _0715_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__and2_1
X_3354_ _0664_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_2
X_3285_ _0597_ _0591_ _0600_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a21boi_4
X_5024_ _2010_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4808_ _1840_ _1841_ VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__nor2_2
X_4739_ _1782_ _1783_ _1781_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_79_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_88_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3070_ _0352_ _0396_ _0408_ _0326_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_85_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3972_ net502 _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2923_ _0270_ _0240_ _0289_ _0216_ _2188_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__a221o_1
XFILLER_0_72_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2854_ _2093_ _0211_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__and2_1
X_2785_ _2094_ _0105_ _0148_ _0155_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__and4_1
XFILLER_0_127_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4524_ _0364_ _0431_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4455_ _0742_ _0758_ _1532_ _0757_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__a22o_1
XFILLER_0_111_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4386_ net323 net312 VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__nand2_1
X_3406_ _0712_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3337_ net1 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3268_ _0584_ _0588_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__and3b_2
X_3199_ _0497_ _0498_ _0508_ _0509_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a31o_1
X_5007_ _1751_ net451 VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__and2b_1
XANTENNA_108 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_119 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_138_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2570_ _2275_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_2
XFILLER_0_22_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput307 net307 VGND VGND VPWR VPWR out2_2[5] sky130_fd_sc_hd__buf_1
Xoutput329 net329 VGND VGND VPWR VPWR out2_4[5] sky130_fd_sc_hd__buf_1
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput318 net318 VGND VGND VPWR VPWR out2_3[5] sky130_fd_sc_hd__buf_1
X_4240_ _1395_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__nor2_2
XFILLER_0_77_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xsub_module16_577 VGND VGND VPWR VPWR sub_module16_577/HI out1[0] sky130_fd_sc_hd__conb_1
XFILLER_0_22_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4171_ _1338_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__inv_2
XFILLER_0_93_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3122_ _2102_ _0210_ _0452_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__and3_2
X_3053_ _2131_ _0301_ _0395_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__and3_2
XFILLER_0_89_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3955_ net298 net217 VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2906_ _0273_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__and2_2
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3886_ _0693_ _0907_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2837_ net6 net7 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__and2b_1
X_2768_ _0075_ _0151_ _0145_ _0152_ _0076_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__a2111oi_4
XFILLER_0_115_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2699_ sm2.s2.t2.A_wire\[3\] sm2.s2.t2.A_wire\[4\] _0092_ VGND VGND VPWR VPWR _0093_
+ sky130_fd_sc_hd__o21ai_1
X_4507_ net140 net153 VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4438_ _1537_ _1548_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__nand3_2
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4369_ _1495_ _1496_ VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_29_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_106_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_19 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_67_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3740_ net255 net340 VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_418 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3671_ net27 _2113_ _0935_ _2093_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__o31a_1
XFILLER_0_12_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2622_ _2247_ _2300_ _2318_ _2319_ _2320_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_70_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_136_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput115 net115 VGND VGND VPWR VPWR final_sum1[6] sky130_fd_sc_hd__buf_1
XFILLER_0_2_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2553_ _2234_ _2249_ _2255_ _2242_ _2233_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__a221o_1
Xoutput159 net159 VGND VGND VPWR VPWR final_sum5[10] sky130_fd_sc_hd__buf_1
Xoutput137 net137 VGND VGND VPWR VPWR final_sum3[2] sky130_fd_sc_hd__buf_1
Xoutput126 net126 VGND VGND VPWR VPWR final_sum2[4] sky130_fd_sc_hd__buf_1
Xoutput148 net148 VGND VGND VPWR VPWR final_sum4[12] sky130_fd_sc_hd__buf_1
XFILLER_0_50_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2484_ _2198_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_2
XFILLER_0_120_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4223_ _1379_ _1360_ _1380_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__nor3_1
XFILLER_0_128_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4154_ _0534_ _0614_ _1300_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4085_ _1272_ _1274_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__xor2_2
X_3105_ net8 net10 VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__or2b_1
X_3036_ net17 net20 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4987_ _1981_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_34_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3938_ _0690_ _1094_ _1096_ _0683_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__a22o_2
XFILLER_0_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3869_ net485 _1097_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__xnor2_4
XFILLER_0_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput28 addr6[2] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
Xinput17 addr4[1] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_2
XFILLER_0_52_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput39 addr8[3] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_2
XFILLER_0_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4910_ _1921_ _1918_ _1922_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__a21o_1
X_4841_ net550 _1855_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_138_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4772_ _1810_ _1812_ VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_31_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3723_ _2232_ net337 VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xor2_4
XFILLER_0_70_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3654_ _0724_ _0889_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__and2_1
XFILLER_0_130_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2605_ _2093_ _2217_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3585_ _0809_ _0834_ _0847_ _0793_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2536_ _2230_ _2234_ _2239_ _2242_ _2233_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__a221o_1
X_2467_ sm2.s1.t2.A_wire\[10\] _2167_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__and2_1
X_5255_ net188 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_1
X_4206_ _1366_ _1350_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__o21a_2
X_2398_ _2105_ _2114_ _2118_ _2100_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_3_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5186_ clknet_3_0__leaf_clk _0022_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[9\] sky130_fd_sc_hd__dfxtp_2
X_4137_ _1309_ _1310_ VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__xnor2_4
XFILLER_0_3_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4068_ net127 net114 VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__xor2_2
X_3019_ _0320_ _0317_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput490 net490 VGND VGND VPWR VPWR sum_out1[8] sky130_fd_sc_hd__buf_1
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_66_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_133_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3370_ _0679_ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_2
X_5040_ _2017_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_109_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4824_ _1853_ _1854_ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__nor2_4
XFILLER_0_90_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_117_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4755_ net545 _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_90_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3706_ _2140_ _0957_ _0967_ _0969_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__o22a_1
XFILLER_0_126_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4686_ _1755_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_2
XFILLER_0_31_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3637_ _0913_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_2
X_3568_ _0782_ _0838_ _0839_ _0780_ _2122_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__a221o_1
X_2519_ sm2.s1.t1.A_wire\[3\] _2227_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__xor2_4
X_3499_ _0787_ _0779_ _0793_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_126_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5238_ net111 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_1
X_5169_ clknet_3_5__leaf_clk _0005_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_108_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_135_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2870_ _0239_ _0221_ _0240_ _0217_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a221o_1
XFILLER_0_127_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4540_ _0742_ _0789_ _1532_ _0787_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4471_ _1576_ _1577_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3422_ _2089_ _0695_ _0721_ _0726_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__o22a_2
X_3353_ _0657_ _0659_ _0662_ _0658_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a221o_1
X_3284_ _0602_ _0604_ VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__nand2_2
X_5023_ _2082_ _0444_ _2090_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_60 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4807_ _1837_ _1838_ _1839_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2999_ sm1.s2.t2.A_wire\[8\] VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4738_ _1781_ _1782_ _1783_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4669_ _1726_ _1727_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__and2b_1
XFILLER_0_101_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_124_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3971_ _0263_ _1087_ _1089_ _0261_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2922_ _0283_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2853_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__inv_2
X_2784_ _2149_ _0153_ _0148_ _0102_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o211a_1
XFILLER_0_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ net246 net330 VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_96_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4454_ _1559_ _1560_ _1562_ _1563_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__nand4_1
XFILLER_0_40_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4385_ _1506_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_2
XFILLER_0_0_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3405_ _2087_ _0668_ _0705_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__o22a_1
X_3336_ _0648_ VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__inv_2
X_3267_ _0500_ _0496_ _0498_ net33 VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__or4b_1
X_5006_ _1764_ net452 VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__xnor2_1
X_3198_ _2084_ _0515_ _0511_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a21oi_2
XANTENNA_109 net129 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_105_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput308 net308 VGND VGND VPWR VPWR out2_2[6] sky130_fd_sc_hd__buf_1
XFILLER_0_22_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput319 net319 VGND VGND VPWR VPWR out2_3[6] sky130_fd_sc_hd__buf_1
Xsub_module16_578 VGND VGND VPWR VPWR sub_module16_578/HI out1_3[0] sky130_fd_sc_hd__conb_1
X_4170_ _1332_ _1337_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_91_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3121_ _0459_ _0461_ _0208_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o21a_1
X_3052_ _0337_ _0397_ _0400_ _0319_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a221o_1
XFILLER_0_89_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3954_ net298 net217 VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3885_ _0693_ _0907_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nand2_1
X_2905_ _0270_ _0260_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2836_ net10 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_100_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2767_ _0064_ _0071_ _0079_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__and3_1
XFILLER_0_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2698_ sm2.s2.t2.A_wire\[5\] VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__buf_4
X_4506_ net140 net153 VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4437_ _1546_ _1547_ net138 VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4368_ net185 net198 VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4299_ net280 net368 VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__and2_1
X_3319_ _0554_ _0605_ _0615_ _0552_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_29_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3670_ _2108_ _0937_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nand2_4
XFILLER_0_70_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2621_ _2309_ _2307_ _2230_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__and3b_1
XFILLER_0_70_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_136_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput116 net116 VGND VGND VPWR VPWR final_sum1[7] sky130_fd_sc_hd__buf_1
XFILLER_0_23_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2552_ _2259_ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__buf_2
Xoutput138 net138 VGND VGND VPWR VPWR final_sum3[3] sky130_fd_sc_hd__buf_1
Xoutput127 net127 VGND VGND VPWR VPWR final_sum2[5] sky130_fd_sc_hd__buf_1
Xoutput149 net149 VGND VGND VPWR VPWR final_sum4[1] sky130_fd_sc_hd__buf_1
XFILLER_0_63_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2483_ _2192_ _2194_ _2197_ _2155_ _2177_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__o32a_1
X_4222_ _1379_ _1360_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__o21a_1
XFILLER_0_128_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4153_ _0534_ _0614_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__or2_1
X_4084_ _1269_ _1271_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_37_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3104_ _0210_ net8 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__or2b_1
X_3035_ _0310_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__inv_2
XFILLER_0_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4986_ net446 net461 VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3937_ _1156_ VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_34_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3868_ _1094_ _1096_ _0650_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_33_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2819_ _0197_ VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__inv_2
X_3799_ _1046_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__or2_2
XFILLER_0_41_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput18 addr4[2] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput29 addr6[3] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_295 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4840_ net551 _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__xor2_2
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4771_ net164 net177 _1811_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_31_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3722_ _2226_ _2303_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__or2_2
XFILLER_0_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3653_ _0926_ VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_130_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2604_ _2102_ _2213_ _2237_ _2299_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3584_ _0868_ VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2535_ _2244_ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__inv_2
X_2466_ sm2.s1.t2.A_wire\[10\] _2167_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nor2_1
X_5254_ net184 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__clkbuf_1
X_4205_ net559 _1345_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nand2_1
X_5185_ clknet_3_2__leaf_clk _0021_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
X_2397_ _2115_ _2117_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__and2_2
X_4136_ _1299_ _1301_ _1300_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_3_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4067_ _1258_ _1260_ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__xor2_2
XFILLER_0_78_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3018_ _0372_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nor2_4
XFILLER_0_78_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4969_ _1964_ _1965_ _1967_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_80_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_111_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput480 net480 VGND VGND VPWR VPWR sum_out1[0] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput491 net491 VGND VGND VPWR VPWR sum_out1[9] sky130_fd_sc_hd__buf_1
XFILLER_0_88_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_133_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4823_ _1851_ _1840_ _1852_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__nor3_1
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4754_ _1794_ _1796_ _2090_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__o21a_2
XFILLER_0_90_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3705_ _2161_ _0946_ _0945_ _2155_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a221o_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_99_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4685_ net506 _1741_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3636_ _0658_ _0904_ _0908_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o22a_1
X_3567_ _0771_ _0844_ _0849_ _0758_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a221o_1
XFILLER_0_101_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2518_ _2210_ _2220_ _2225_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__nor3_4
X_3498_ sm1.s2.t1.A_wire\[7\] sm1.s2.t1.A_wire\[8\] _0779_ VGND VGND VPWR VPWR _0794_
+ sky130_fd_sc_hd__or3_4
X_5237_ net110 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__clkbuf_2
X_2449_ _2147_ _2156_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__nor2_1
X_5168_ clknet_3_5__leaf_clk _0004_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[7\] sky130_fd_sc_hd__dfxtp_1
X_4119_ _1297_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_2
X_5099_ _2048_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_136_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4470_ _1552_ _1555_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3421_ _0698_ _0699_ _0724_ _0657_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3352_ _2083_ _0650_ _0652_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__and3_1
X_3283_ _0524_ _0594_ _0603_ _0517_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_0_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5022_ _2006_ _2009_ _2007_ VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__a21o_1
XFILLER_0_136_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4806_ _1837_ _1838_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2998_ _0331_ _0347_ _0353_ _0334_ _0328_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a221o_1
X_4737_ _2112_ _2119_ _2125_ _0944_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4668_ _1740_ _1741_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_16_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3619_ _0668_ _0890_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__and2_1
X_4599_ _1660_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3970_ _1182_ _1183_ VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__xor2_4
XFILLER_0_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2921_ _0288_ VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_2
XFILLER_0_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_266 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2852_ net10 net8 _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__or3_1
X_2783_ _2083_ _0079_ _0163_ _0155_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__and4_2
XFILLER_0_122_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4522_ _1595_ _1618_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__a21o_2
X_4453_ _1559_ _1560_ _1562_ _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__a31o_2
XTAP_TAPCELL_ROW_96_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3404_ _0698_ _0677_ _0709_ _0657_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4384_ _0444_ _0764_ _0737_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__and3_1
X_3335_ _2204_ _0571_ _0642_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a2bb2o_2
X_3266_ _0585_ _0586_ _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5005_ _1995_ _1996_ VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__xor2_1
X_3197_ _0517_ _0526_ _0527_ _0516_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_105_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput309 net309 VGND VGND VPWR VPWR out2_2[7] sky130_fd_sc_hd__buf_1
Xsub_module16_579 VGND VGND VPWR VPWR sub_module16_579/HI out1_7[0] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_91_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3120_ _0453_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nor2_2
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3051_ _0329_ _0401_ _0402_ _2110_ _0299_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_77_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3953_ _1169_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__inv_2
XFILLER_0_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3884_ net295 net214 VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2904_ sm1.s1.t2.A_wire\[9\] _0260_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2835_ _0209_ VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_2
XFILLER_0_115_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2766_ _0144_ _0150_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2697_ sm2.s2.t2.A_wire\[3\] sm2.s2.t2.A_wire\[4\] sm2.s2.t2.A_wire\[5\] VGND VGND
+ VPWR VPWR _0091_ sky130_fd_sc_hd__or3_1
XFILLER_0_130_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4505_ _1603_ _1606_ VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__xor2_2
X_4436_ net138 _1546_ _1547_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__nand3_2
XFILLER_0_13_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4367_ _1490_ _1492_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__o21ai_2
X_3318_ _0560_ _0599_ _0603_ _0562_ _2187_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__a221o_1
XFILLER_0_67_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4298_ _1431_ _1432_ _1429_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__a21oi_4
X_3249_ _0515_ _0513_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_29_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_125_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_129_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2620_ _2237_ _2299_ _2305_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_136_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput106 net106 VGND VGND VPWR VPWR final_sum1[0] sky130_fd_sc_hd__buf_1
X_2551_ _2254_ _2256_ _2258_ _2252_ _2237_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__o32a_1
X_2482_ _2100_ _2195_ _2184_ _2128_ _2196_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__a221o_1
Xoutput128 net128 VGND VGND VPWR VPWR final_sum2[6] sky130_fd_sc_hd__buf_1
Xoutput139 net139 VGND VGND VPWR VPWR final_sum3[4] sky130_fd_sc_hd__buf_1
Xoutput117 net117 VGND VGND VPWR VPWR final_sum1[8] sky130_fd_sc_hd__buf_1
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4221_ net277 net364 VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4152_ net274 net361 VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_128_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3103_ _0446_ VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__inv_2
X_4083_ net129 net116 VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__nand2_1
X_3034_ _0387_ VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_2
XFILLER_0_37_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4985_ net446 net461 VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3936_ _1154_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_34_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_364 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3867_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__buf_4
XFILLER_0_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2818_ _2202_ _0109_ _0196_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o21ai_4
X_3798_ _1042_ _1043_ _1045_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2749_ _0117_ _0100_ _0137_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4419_ _0742_ _1532_ _0737_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_6_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 addr4[3] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_2
XFILLER_0_122_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4770_ _1792_ _1799_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3721_ _2244_ net338 VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xor2_2
XFILLER_0_70_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3652_ _0923_ _0924_ _0925_ _0904_ _0695_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__o32a_1
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3583_ _2087_ _0780_ _0865_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o22a_1
XFILLER_0_70_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2603_ _2303_ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__inv_2
XFILLER_0_3_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2534_ _2235_ _2241_ _2243_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__nor3_4
XFILLER_0_23_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5253_ net176 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__clkbuf_1
X_2465_ _2123_ _2180_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__nor2_1
X_2396_ sm2.s1.t2.A_wire\[3\] sm2.s1.t2.A_wire\[4\] _2116_ VGND VGND VPWR VPWR _2117_
+ sky130_fd_sc_hd__o21ai_1
X_4204_ net559 _1345_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__nor2_1
X_5184_ clknet_3_2__leaf_clk _0020_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_4135_ _0534_ _0614_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_3_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4066_ net125 net112 _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3017_ _0373_ _0371_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nor2_2
XFILLER_0_78_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4968_ _1964_ _1965_ _1967_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__or3_1
XFILLER_0_46_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4899_ _1471_ _1800_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__and2_1
X_3919_ _1120_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__inv_2
XFILLER_0_131_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput470 net470 VGND VGND VPWR VPWR partial_sum16[15] sky130_fd_sc_hd__buf_1
Xoutput492 net492 VGND VGND VPWR VPWR sum_out2[0] sky130_fd_sc_hd__buf_1
Xoutput481 net481 VGND VGND VPWR VPWR sum_out1[10] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_122_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4822_ _1851_ _1840_ _1852_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_16_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4753_ _1795_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_28_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3704_ _2168_ _0942_ _0951_ _2151_ _0949_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4684_ _1740_ VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3635_ _0683_ _0890_ _0909_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__a211o_1
XFILLER_0_31_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3566_ _2083_ _0764_ sm1.s2.t1.A_wire\[7\] _0831_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__and4_1
XFILLER_0_113_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3497_ sm1.s2.t1.A_wire\[8\] VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__buf_2
X_2517_ net25 _2220_ _2225_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__nor3_4
X_2448_ _2165_ VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_2
X_5236_ net106 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5167_ clknet_3_5__leaf_clk _0003_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
X_2379_ net105 VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__buf_4
X_4118_ _2357_ _0148_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__and2_1
X_5098_ _0495_ net89 _2045_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_3_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4049_ _1242_ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_108_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3420_ _0703_ _0681_ _0685_ _0709_ _2188_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a221o_1
XFILLER_0_52_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3351_ _0660_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3282_ _0597_ _0590_ _0598_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a21boi_4
X_5021_ _2006_ _2009_ VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4805_ net353 net267 VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2997_ _0356_ VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__inv_2
XFILLER_0_8_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4736_ _2112_ _2119_ _2125_ _0944_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__a31o_1
XFILLER_0_114_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4667_ net505 _1721_ _1723_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_71_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3618_ _0672_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4598_ net390 net404 VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__xor2_1
X_3549_ _0749_ _0831_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_8_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5219_ clknet_3_3__leaf_clk _0055_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2920_ _2088_ _0252_ _0282_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__o22a_1
XFILLER_0_127_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_75_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_122_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2851_ net6 net7 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__or2_2
XFILLER_0_127_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_122_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2782_ _0161_ _0165_ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__nand2_2
X_4521_ _1596_ net523 VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_130_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4452_ net234 net317 VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_96_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3403_ _0683_ _0681_ _0685_ _0690_ _2172_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_84_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4383_ net231 net314 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__xor2_4
X_3334_ _0568_ _0619_ _0646_ _0567_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__o2bb2a_1
X_3265_ net33 net35 VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__xnor2_1
X_5004_ _1991_ _1994_ _1990_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__a21o_1
X_3196_ _0499_ _0518_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__and2_2
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_93_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_328 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4719_ _1671_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__inv_2
XFILLER_0_32_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3050_ _0310_ _0300_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3952_ _1166_ _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3883_ _1094_ _1096_ _0650_ net485 VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__o211a_2
XFILLER_0_45_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2903_ _0261_ _0243_ _0263_ _0257_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a221o_1
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2834_ _2088_ net6 _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__and3_1
XFILLER_0_115_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2765_ _0064_ net40 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4504_ _1604_ _1577_ _1605_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2696_ _0088_ _0089_ _2357_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__o21a_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4435_ _1544_ _1545_ _1540_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4366_ net196 net209 VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__nand2_1
X_3317_ _0568_ _0594_ _0619_ _0547_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a22o_1
X_4297_ _1442_ _1443_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__xor2_4
X_3248_ _0573_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_29_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _0502_ _0507_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR final_sum1[10] sky130_fd_sc_hd__buf_1
X_2550_ _2257_ _2228_ _2240_ _2247_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__a22o_1
X_2481_ _2150_ _2178_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__nor2_1
Xoutput129 net129 VGND VGND VPWR VPWR final_sum2[7] sky130_fd_sc_hd__buf_1
Xoutput118 net118 VGND VGND VPWR VPWR final_sum1[9] sky130_fd_sc_hd__buf_1
X_4220_ net276 net363 VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__and2_1
X_4151_ _1311_ _1313_ net557 _0495_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o211a_2
XFILLER_0_37_20 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4082_ _1188_ _1196_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__xor2_2
X_3102_ _0444_ _0373_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__o21ai_4
X_3033_ _2089_ _0310_ _0299_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__and3_1
XFILLER_0_53_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4984_ _1978_ _1980_ VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__xnor2_1
X_3935_ _1133_ _1153_ _1151_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_34_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3866_ _0672_ net4 VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2817_ _2193_ _0192_ _0193_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__or4_2
XFILLER_0_116_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3797_ _1042_ _1043_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__a21oi_2
X_2748_ _0089_ _0120_ _0136_ _0088_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2679_ net36 VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_4
X_4418_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_113_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4349_ net193 net206 VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_68_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3720_ _0980_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_138_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3651_ _0709_ _0898_ _0896_ _0703_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a22o_1
X_3582_ _0801_ _0834_ _0847_ _0787_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a221o_1
X_2602_ _2227_ _2300_ _2301_ _2230_ _2302_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__a221oi_4
X_2533_ _2237_ _2228_ _2230_ _2242_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2464_ _2167_ _2169_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__nand2_1
X_5252_ net175 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__clkbuf_1
X_2395_ sm2.s1.t2.A_wire\[5\] VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__buf_2
X_4203_ net560 _1364_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__xor2_2
X_5183_ clknet_3_0__leaf_clk _0019_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4134_ _1308_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_3_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4065_ _1257_ _1256_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__and2b_1
X_3016_ sm1.s2.t2.A_wire\[10\] VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__buf_4
XFILLER_0_93_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4967_ _1961_ _1963_ _1966_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__o21a_1
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4898_ _1471_ _1800_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nor2_1
X_3918_ net308 net226 VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_46_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3849_ net293 net212 VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__xor2_4
XFILLER_0_131_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_131_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput460 net460 VGND VGND VPWR VPWR partial_sum15_1[6] sky130_fd_sc_hd__buf_1
Xoutput471 net471 VGND VGND VPWR VPWR partial_sum16[1] sky130_fd_sc_hd__buf_1
Xoutput493 net493 VGND VGND VPWR VPWR sum_out2[10] sky130_fd_sc_hd__buf_1
Xoutput482 net482 VGND VGND VPWR VPWR sum_out1[11] sky130_fd_sc_hd__buf_1
XFILLER_0_69_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_135_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_133_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4821_ net354 net268 VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4752_ _2108_ net29 VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__and2b_1
XFILLER_0_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3703_ _2180_ _0939_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nor2_1
X_4683_ _1752_ _1750_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3634_ _0690_ _0889_ _0910_ _0659_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3565_ _0852_ VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__inv_2
X_3496_ _0766_ _0782_ _0789_ _0772_ _0763_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__a221o_1
X_2516_ sm2.s1.t1.A_wire\[4\] VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2447_ _2158_ _2164_ _2087_ _2116_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5166_ clknet_3_5__leaf_clk _0002_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_2378_ _2082_ _2094_ _2099_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__and3_2
X_4117_ _1296_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_4
X_5097_ _2047_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4048_ _1247_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_108_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_104_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput290 net290 VGND VGND VPWR VPWR out2[0] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_113_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_122_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3350_ _0653_ _0655_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_21_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3281_ _0522_ _0592_ _0599_ _0516_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a221oi_4
X_5020_ _2007_ _2008_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_131_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4804_ _1813_ _1831_ _1832_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__or3_1
X_4735_ net347 net261 VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__and2_1
X_2996_ _0326_ _0342_ _0351_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_8_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4666_ _1717_ _1720_ _1719_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_71_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4597_ _1662_ _1682_ VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__xor2_2
X_3617_ _2083_ _0892_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__and2_1
X_3548_ _2093_ _0739_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3479_ _0753_ _0762_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__or2_2
X_5218_ clknet_3_3__leaf_clk _0054_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5149_ _2074_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_130_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2850_ _0223_ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_26_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2781_ _0092_ _0154_ _0162_ _0085_ _0164_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_13_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4520_ _1596_ net523 VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4451_ _1561_ _1516_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_96_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3402_ _0707_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2_2
X_4382_ _1433_ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__inv_2
XFILLER_0_21_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3333_ _0605_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3264_ net32 net31 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5003_ _1751_ net451 VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__xnor2_1
X_3195_ _0498_ _0518_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and2_2
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2979_ _0340_ VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__inv_2
XFILLER_0_133_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4718_ _1691_ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__inv_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4649_ _1725_ _1703_ _1700_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_102_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3951_ _1144_ _1145_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_58_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2902_ _0270_ _0219_ _0220_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__and3_1
X_3882_ _1109_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__inv_2
XFILLER_0_42_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2833_ sm1.s1.t2.A_wire\[3\] VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2764_ _0149_ VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_100_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4503_ net386 net400 VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2695_ _2102_ _0077_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__and2_2
XFILLER_0_6_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4434_ _1540_ _1544_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__nand3_4
X_4365_ _1493_ VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__inv_2
X_3316_ _0632_ VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_2
X_4296_ _1424_ _1426_ _1423_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a21oi_2
X_3247_ _0569_ _0570_ _0572_ _0543_ _0552_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__o32a_1
XTAP_TAPCELL_ROW_29_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3178_ _2121_ _0508_ _0509_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nor4_2
XFILLER_0_138_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_37_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2480_ _2186_ _2167_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__or2_1
XFILLER_0_105_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput119 net119 VGND VGND VPWR VPWR final_sum2[0] sky130_fd_sc_hd__buf_1
Xoutput108 net108 VGND VGND VPWR VPWR final_sum1[11] sky130_fd_sc_hd__buf_1
XFILLER_0_50_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4150_ _1318_ net569 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__xnor2_4
XFILLER_0_37_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3101_ _0375_ _0413_ _0411_ _0384_ _0442_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a221o_1
X_4081_ _1269_ _1271_ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__xor2_2
X_3032_ _0386_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__inv_2
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4983_ _1973_ _1975_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__a21o_1
X_3934_ _1133_ _1151_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_34_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_128_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3865_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2816_ _0111_ _0177_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3796_ _1007_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__xnor2_1
X_2747_ _0123_ _0097_ _0134_ _0084_ _0135_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2678_ _0073_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__buf_2
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4417_ net14 _0745_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_113_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4348_ _1478_ _1477_ _1479_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_6_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4279_ net289 net377 VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_134_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_122_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3650_ _0719_ _0890_ _0910_ _0699_ _0909_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__a221o_1
X_3581_ _0796_ _0838_ _0839_ _0793_ _2144_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a221o_1
X_2601_ _2110_ _2208_ _2217_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__and3_1
XFILLER_0_113_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2532_ _2131_ net25 _2220_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__and3_2
XFILLER_0_51_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5251_ net171 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2463_ _2147_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__nor2_1
X_4202_ _1311_ _0539_ _1313_ _0537_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__a22o_1
X_2394_ sm2.s1.t2.A_wire\[3\] sm2.s1.t2.A_wire\[4\] sm2.s1.t2.A_wire\[5\] VGND VGND
+ VPWR VPWR _2115_ sky130_fd_sc_hd__or3_1
X_5182_ clknet_3_0__leaf_clk _0018_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
X_4133_ _1304_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_48_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4064_ _1109_ _1117_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_3_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3015_ sm1.s2.t2.A_wire\[10\] _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4966_ net441 net456 VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4897_ _1910_ _1912_ VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__xor2_2
X_3917_ _1136_ _1138_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3848_ net292 net211 VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__and2_2
XFILLER_0_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3779_ _0986_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__nor2_2
XFILLER_0_89_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput450 net450 VGND VGND VPWR VPWR partial_sum15_1[10] sky130_fd_sc_hd__buf_1
Xoutput461 net461 VGND VGND VPWR VPWR partial_sum15_1[7] sky130_fd_sc_hd__buf_1
Xoutput494 net494 VGND VGND VPWR VPWR sum_out2[11] sky130_fd_sc_hd__buf_1
Xoutput483 net483 VGND VGND VPWR VPWR sum_out1[1] sky130_fd_sc_hd__buf_1
Xoutput472 net472 VGND VGND VPWR VPWR partial_sum16[2] sky130_fd_sc_hd__buf_1
XFILLER_0_96_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_135_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4820_ net353 net267 VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4751_ _1793_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__buf_4
XFILLER_0_83_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3702_ _0966_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__buf_4
XFILLER_0_70_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4682_ net380 net394 VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3633_ _0899_ _0900_ _0901_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_99_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3564_ _0846_ _0848_ _0850_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nor4b_4
X_3495_ _0791_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2515_ _2226_ VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__inv_2
X_2446_ _2150_ _2145_ _2162_ _2163_ _2086_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__o2111a_1
XTAP_TAPCELL_ROW_110_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5165_ clknet_3_5__leaf_clk _0001_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
X_2377_ _2096_ _2098_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__xor2_1
X_4116_ _0444_ _0501_ _0495_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5096_ _0280_ net56 _2045_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__mux2_1
X_4047_ _1239_ _1226_ net494 VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_108_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4949_ _1952_ _1953_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput280 net280 VGND VGND VPWR VPWR out1_8[10] sky130_fd_sc_hd__buf_1
Xoutput291 net291 VGND VGND VPWR VPWR out2[10] sky130_fd_sc_hd__buf_1
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_431 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3280_ _0495_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_136_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4803_ net352 net266 VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2995_ _0352_ _0322_ _0333_ _0344_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a221o_1
XFILLER_0_8_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4734_ _1775_ _1780_ VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__xor2_4
XFILLER_0_44_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4665_ _1715_ _1737_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4596_ _1671_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__xor2_2
X_3616_ _0894_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
XFILLER_0_101_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3547_ _0836_ VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3478_ _0776_ VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__inv_2
X_2429_ _2145_ _2147_ _2130_ _2116_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__a2bb2o_1
X_5217_ clknet_3_3__leaf_clk _0053_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5148_ _2090_ net81 _2067_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__mux2_1
X_5079_ _0718_ net48 _2034_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2780_ _2357_ _0079_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4450_ _0846_ _0848_ _0850_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_96_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4381_ _1500_ _1504_ _1505_ VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__a21oi_2
X_3401_ _0695_ _0688_ _0703_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__o21ai_1
X_3332_ _0645_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3263_ _0500_ _0496_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nand2_1
X_3194_ _0515_ _0513_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__and3_1
X_5002_ _1992_ _1994_ VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_105_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2978_ _0326_ _0322_ _0332_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_8_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4717_ _1773_ VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__inv_2
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4648_ _1701_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__inv_2
XFILLER_0_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4579_ _1665_ _1666_ VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_73_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3950_ _1142_ _1143_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__and2b_1
XFILLER_0_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2901_ sm1.s1.t2.A_wire\[9\] VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3881_ _1098_ _1108_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2832_ _2204_ _0132_ _0204_ _0207_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__o22a_2
XFILLER_0_73_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2763_ _2357_ _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_100_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_131_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4502_ net386 net400 VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2694_ _2131_ net40 _0081_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_123_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4433_ _1542_ _1543_ _1541_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__a21o_1
X_4364_ _1490_ _1492_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3315_ _0628_ _0629_ _0631_ _0537_ _2087_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__o32a_1
X_4295_ _1440_ _1441_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__nand2_2
XFILLER_0_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3246_ _0571_ _0519_ _0527_ _0560_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_57_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3177_ _0498_ _0497_ _0496_ _0500_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and4b_1
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_136_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput109 net109 VGND VGND VPWR VPWR final_sum1[12] sky130_fd_sc_hd__buf_1
XFILLER_0_120_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3100_ _2204_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__clkbuf_8
X_4080_ _1267_ _1268_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_37_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3031_ _0373_ _0342_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_102_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4982_ net444 net459 VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3933_ _1111_ _1114_ _1152_ _1130_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_34_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3864_ net4 _0672_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__and2b_1
X_2815_ _0132_ _0154_ _0166_ _0120_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3795_ _2296_ _2249_ _1028_ _2247_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_61_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2746_ _0132_ _0083_ _0095_ _0126_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2677_ _0066_ _0070_ _0072_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__or3b_1
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4416_ _1529_ _1530_ VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__xnor2_2
XFILLER_0_111_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4347_ net192 net205 VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__nand2_1
X_4278_ _1315_ _0126_ _1317_ _0123_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a22oi_4
X_3229_ _0537_ _0543_ _0550_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o22a_1
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_334 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_134_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3580_ _0789_ _0844_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a21o_1
X_2600_ _2299_ _2213_ _2094_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__and3b_2
XFILLER_0_125_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2531_ _2229_ _2239_ _2240_ _2227_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5250_ net163 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_1
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2462_ _2159_ _2160_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__nand2_1
X_4201_ _1363_ VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__buf_2
XFILLER_0_48_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2393_ net27 _2113_ _2102_ _2103_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__and4_2
XFILLER_0_48_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5181_ clknet_3_0__leaf_clk _0017_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
X_4132_ _1305_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4063_ _1256_ _1257_ VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3014_ sm1.s2.t2.A_wire\[9\] _0359_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4965_ _1555_ _1556_ net457 VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3916_ net487 _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__xor2_4
XFILLER_0_80_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4896_ net420 net406 _1907_ _1911_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3847_ _1079_ _1080_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__xor2_4
XFILLER_0_46_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3778_ _0986_ _1029_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__xor2_4
XFILLER_0_14_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2729_ _0118_ _0119_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__and2_2
XFILLER_0_131_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput440 net440 VGND VGND VPWR VPWR partial_sum15[1] sky130_fd_sc_hd__buf_1
Xoutput451 net451 VGND VGND VPWR VPWR partial_sum15_1[11] sky130_fd_sc_hd__buf_1
Xoutput462 net462 VGND VGND VPWR VPWR partial_sum15_1[8] sky130_fd_sc_hd__buf_1
Xoutput495 net495 VGND VGND VPWR VPWR sum_out2[1] sky130_fd_sc_hd__buf_1
Xoutput484 net484 VGND VGND VPWR VPWR sum_out1[2] sky130_fd_sc_hd__buf_1
Xoutput473 net473 VGND VGND VPWR VPWR partial_sum16[3] sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_138_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4750_ net29 _2108_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__and2b_1
XFILLER_0_55_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3701_ _2126_ _0957_ _0963_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o22a_1
XFILLER_0_126_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4681_ net380 net394 VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_99_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3632_ _0887_ _0895_ _0903_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nor3_2
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3563_ _2144_ _0737_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nand2_1
X_3494_ _0786_ _0788_ _0790_ _0777_ _0769_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o32a_1
X_2514_ _2209_ _2220_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__or3_4
XFILLER_0_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2445_ _2126_ _2130_ _2141_ _2147_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_110_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5164_ clknet_3_5__leaf_clk _0000_ VGND VGND VPWR VPWR sm1.s2.t1.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_2376_ net28 _2097_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__xnor2_2
X_4115_ _1223_ VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__inv_2
XFILLER_0_75_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5095_ _2046_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_4046_ _1246_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_65_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_136_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4948_ net424 net410 VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4879_ net161 net174 VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_131_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput270 net270 VGND VGND VPWR VPWR out1_7[10] sky130_fd_sc_hd__buf_1
Xoutput281 net281 VGND VGND VPWR VPWR out1_8[1] sky130_fd_sc_hd__buf_1
Xoutput292 net292 VGND VGND VPWR VPWR out2[1] sky130_fd_sc_hd__buf_1
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2994_ _0320_ _0317_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__and3_1
X_4802_ _1827_ _1836_ VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__xor2_2
X_4733_ _1778_ _1779_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__nand2_2
XFILLER_0_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4664_ net133 net146 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_54_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3615_ _0659_ _0889_ _0890_ _0658_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__a221o_1
X_4595_ _1678_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__xnor2_4
X_3546_ _0757_ _0832_ _0834_ _0758_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a221o_1
XFILLER_0_114_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3477_ _0767_ _0773_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor3_4
X_5216_ clknet_3_1__leaf_clk _0052_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[7\] sky130_fd_sc_hd__dfxtp_2
X_2428_ _2146_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_71_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2359_ net26 VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__clkbuf_2
X_5147_ _2073_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_5078_ _2037_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_4029_ _1231_ _1233_ VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__xor2_4
XFILLER_0_94_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_127_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4380_ net187 net200 VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__nor2_1
X_3400_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3331_ _2204_ _0560_ _0643_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__o22a_1
X_3262_ _0583_ _0499_ _0497_ _0500_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a211oi_1
X_3193_ _0521_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__and2_2
X_5001_ _1988_ _1989_ _1993_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_105_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2977_ _0319_ _0333_ _0334_ _0324_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__a221o_1
XFILLER_0_16_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_62_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4716_ _1564_ _1565_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4647_ _1723_ _1724_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_116_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4578_ _1638_ _1640_ _1664_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_73_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3529_ _0819_ _0817_ _0820_ _0777_ _0807_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__o32a_1
XFILLER_0_6_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_127_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_25 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2900_ _0269_ VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__inv_2
XFILLER_0_58_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3880_ _1106_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__and2b_1
XFILLER_0_128_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2831_ _0131_ _0166_ _0177_ _0134_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2762_ _0075_ _0064_ _0145_ _0146_ _0147_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o311a_2
XTAP_TAPCELL_ROW_100_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4501_ _1264_ _1602_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__xor2_2
XFILLER_0_130_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2693_ _0087_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__inv_2
XFILLER_0_1_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4432_ _1541_ _1542_ _1543_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__nand3_2
X_4363_ _1487_ _1489_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3314_ _0560_ _0592_ _0605_ _0547_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__a221o_1
X_4294_ net553 _1439_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3245_ sm2.s2.t1.A_wire\[10\] VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__buf_2
X_3176_ _0496_ net33 _0498_ _0500_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_134_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_117 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_125_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3030_ _0334_ _0384_ _0375_ _0331_ _0382_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__a221o_1
X_4981_ _1976_ _1977_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3932_ net296 net215 VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3863_ _1091_ _1092_ VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_34_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2814_ _0134_ _0156_ _0179_ _0117_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3794_ _1037_ _1038_ _1040_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__or3_1
XFILLER_0_131_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2745_ _0131_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__and2_2
XFILLER_0_103_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2676_ net37 net39 _0071_ _0064_ net36 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__a2111o_1
XTAP_TAPCELL_ROW_113_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4415_ _1510_ _1513_ _1512_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__a21bo_1
X_4346_ net192 net205 VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4277_ _1425_ _1426_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__xor2_4
X_3228_ _0515_ _0513_ _0554_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a31o_1
X_3159_ _0285_ _0459_ _0463_ _0289_ _0489_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_68_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_79_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2530_ _2084_ _2210_ _2220_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__and3_2
XFILLER_0_11_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2461_ _2088_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4200_ _1360_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__and2b_1
X_2392_ _2082_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5180_ clknet_3_0__leaf_clk _0016_ VGND VGND VPWR VPWR sm1.s1.t1.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_4131_ _0087_ _0161_ _0165_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4062_ net124 net111 _1254_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3013_ _0370_ VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_39_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4964_ _1555_ _1556_ net457 VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3915_ _0677_ _1094_ _1096_ _0668_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__a22o_2
XFILLER_0_129_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4895_ net425 net411 VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3846_ net304 net222 VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__xor2_4
XFILLER_0_61_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3777_ _2296_ _1028_ _2208_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__o21ai_4
X_2728_ _0109_ _0103_ _0117_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2659_ _2221_ _2276_ _2309_ _2089_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__o31ai_1
Xoutput441 net441 VGND VGND VPWR VPWR partial_sum15[2] sky130_fd_sc_hd__buf_1
Xoutput430 net430 VGND VGND VPWR VPWR partial_sum14_3[6] sky130_fd_sc_hd__buf_1
Xoutput452 net452 VGND VGND VPWR VPWR partial_sum15_1[12] sky130_fd_sc_hd__buf_1
Xoutput496 net496 VGND VGND VPWR VPWR sum_out2[2] sky130_fd_sc_hd__buf_1
Xoutput485 net485 VGND VGND VPWR VPWR sum_out1[3] sky130_fd_sc_hd__buf_1
Xoutput474 net474 VGND VGND VPWR VPWR partial_sum16[4] sky130_fd_sc_hd__buf_1
Xoutput463 net463 VGND VGND VPWR VPWR partial_sum15_1[9] sky130_fd_sc_hd__buf_1
X_4329_ _1465_ VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3700_ _2151_ _0946_ _0945_ _2140_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__a221o_1
XFILLER_0_83_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4680_ _1751_ VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__inv_2
XFILLER_0_55_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3631_ _0677_ _0898_ _0896_ _0668_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__a22o_1
X_3562_ _0780_ _0832_ _0849_ _0737_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_99_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2513_ _2121_ _2221_ _2223_ _2224_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__or4_4
XFILLER_0_3_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3493_ _0766_ _0771_ _0789_ _0756_ _0763_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a221o_1
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2444_ _2100_ _2161_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_110_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2375_ net27 net26 VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__and2b_1
X_5163_ _2081_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_4114_ _1142_ VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__inv_2
XFILLER_0_75_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5094_ _0270_ net55 _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__mux2_1
X_4045_ _1242_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_108_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4947_ net424 net410 VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__nor2_1
X_4878_ net161 net174 VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_327 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3829_ _1023_ _1026_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput260 net260 VGND VGND VPWR VPWR out1_6[10] sky130_fd_sc_hd__buf_1
Xoutput271 net271 VGND VGND VPWR VPWR out1_7[1] sky130_fd_sc_hd__buf_1
XFILLER_0_100_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput282 net282 VGND VGND VPWR VPWR out1_8[2] sky130_fd_sc_hd__buf_1
Xoutput293 net293 VGND VGND VPWR VPWR out2[2] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_87_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_135_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2993_ sm1.s2.t2.A_wire\[7\] _0345_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__xor2_4
X_4801_ _1048_ net180 VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4732_ net162 net175 VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4663_ net133 net146 VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3614_ _2083_ _0650_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__and3_1
XFILLER_0_43_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4594_ _1649_ _1653_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__a21o_1
X_3545_ _2094_ sm1.s2.t1.A_wire\[3\] _0739_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3476_ _0769_ _0759_ _0774_ _0757_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a22o_1
X_2427_ _2121_ _2103_ _2129_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__or3b_1
X_5215_ clknet_3_1__leaf_clk _0051_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5146_ _2279_ net80 _2067_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_71_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5077_ _0719_ net47 _2034_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__mux2_1
X_4028_ _1208_ _1211_ _1232_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_39_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_26 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_123_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3330_ _0568_ _0605_ _0615_ _0571_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a22o_1
X_3261_ _0496_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__inv_2
X_5000_ net448 net463 VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3192_ sm2.s2.t1.A_wire\[3\] sm2.s2.t1.A_wire\[4\] _0522_ VGND VGND VPWR VPWR _0523_
+ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_0_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_335 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2976_ _0320_ _0317_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4715_ _1772_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_252 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4646_ _1716_ _1693_ _1722_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4577_ _1638_ _1640_ _1664_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3528_ _0766_ _0809_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__and2_1
X_3459_ _0745_ _0744_ _0750_ _0753_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__and4_2
X_5129_ _0132_ net104 _2056_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_127_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2830_ _0206_ VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_1
XFILLER_0_73_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2761_ _0075_ net37 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__or2_1
X_2692_ _0082_ _0083_ _0084_ _0085_ _0086_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a221oi_4
XFILLER_0_108_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_100_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4500_ _1593_ _1601_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__xor2_4
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_1 _0822_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4431_ _0340_ _0409_ _0416_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__nand3_1
XFILLER_0_111_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4362_ net195 net208 VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__and2_1
X_3313_ _0539_ _0619_ _0615_ _0546_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a22o_1
X_4293_ net553 _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__nand2_1
X_3244_ _0531_ _0554_ _0562_ _0526_ _0529_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a221o_1
X_3175_ _0500_ _0496_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nor2_2
XFILLER_0_107_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2959_ _0321_ _0317_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_20_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4629_ _1278_ net405 VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_129_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4980_ net445 net460 VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3931_ _1149_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_196 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3862_ net293 net212 _1081_ _1082_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__a22o_2
XTAP_TAPCELL_ROW_62_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2813_ _0123_ _0160_ _0162_ _0126_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3793_ net535 _1036_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand2_1
X_2744_ _0132_ _0124_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2675_ net40 VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkinv_4
XFILLER_0_75_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_113_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4414_ _1527_ _1528_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__or2b_1
XFILLER_0_78_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4345_ _1475_ _1477_ VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4276_ _1407_ _1408_ _1405_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__o21ai_4
XPHY_EDGE_ROW_129_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3227_ _0552_ _0519_ _0527_ _0546_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3158_ _0492_ VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_68_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3089_ _2202_ _0352_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_92_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_188 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_102_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_138_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_125_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_200 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2460_ _2176_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2391_ net27 _2111_ _2082_ _2090_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__or4b_2
X_4130_ _0161_ _0165_ _0087_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4061_ net125 net112 VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3012_ _0352_ _0342_ _0365_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_78_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4963_ _1962_ _1963_ VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_129_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3914_ _1110_ _1116_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a21o_2
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4894_ _1908_ _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3845_ net303 net221 VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__and2_2
XFILLER_0_61_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3776_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2727_ sm2.s2.t2.A_wire\[7\] sm2.s2.t2.A_wire\[8\] _0103_ VGND VGND VPWR VPWR _0118_
+ sky130_fd_sc_hd__or3_1
Xoutput420 net420 VGND VGND VPWR VPWR partial_sum14_3[0] sky130_fd_sc_hd__buf_1
X_2658_ _2351_ VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkbuf_2
Xoutput453 net453 VGND VGND VPWR VPWR partial_sum15_1[13] sky130_fd_sc_hd__buf_1
Xoutput431 net431 VGND VGND VPWR VPWR partial_sum14_3[7] sky130_fd_sc_hd__buf_1
Xoutput442 net442 VGND VGND VPWR VPWR partial_sum15[3] sky130_fd_sc_hd__buf_1
Xoutput486 net486 VGND VGND VPWR VPWR sum_out1[4] sky130_fd_sc_hd__buf_1
X_2589_ _2290_ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__buf_2
Xoutput475 net475 VGND VGND VPWR VPWR partial_sum16[5] sky130_fd_sc_hd__buf_1
Xoutput464 net464 VGND VGND VPWR VPWR partial_sum16[0] sky130_fd_sc_hd__buf_1
Xoutput497 net497 VGND VGND VPWR VPWR sum_out2[3] sky130_fd_sc_hd__buf_1
X_4328_ _1463_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__or2_2
X_4259_ _1397_ _1398_ _1396_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_2_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_442 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_14 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_126_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3630_ _0907_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__inv_2
XFILLER_0_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3561_ _0764_ _0743_ _0831_ _2101_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__and4b_2
X_2512_ net21 net22 _2211_ _2210_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3492_ _0787_ _0779_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__xor2_4
XFILLER_0_11_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2443_ _2159_ _2160_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_110_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5162_ _2186_ net88 _2011_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__mux2_1
X_2374_ net30 _2095_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nor2_1
X_5093_ _2011_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__buf_4
X_4113_ _1295_ VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__inv_2
XFILLER_0_78_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4044_ _1243_ _1237_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_65_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_121_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4946_ _1948_ _1949_ _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4877_ _1897_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_34_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3828_ net250 net335 VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3759_ net258 net343 VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput250 net250 VGND VGND VPWR VPWR out1_5[10] sky130_fd_sc_hd__buf_1
Xoutput261 net261 VGND VGND VPWR VPWR out1_6[1] sky130_fd_sc_hd__buf_1
XFILLER_0_30_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput272 net272 VGND VGND VPWR VPWR out1_7[2] sky130_fd_sc_hd__buf_1
Xoutput283 net283 VGND VGND VPWR VPWR out1_8[3] sky130_fd_sc_hd__buf_1
Xoutput294 net294 VGND VGND VPWR VPWR out2[3] sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_87_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_123_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4800_ _1830_ _1835_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__xor2_4
XFILLER_0_88_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2992_ sm1.s2.t2.A_wire\[7\] VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_68_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4731_ net162 net175 VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4662_ _1734_ _1736_ VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__xor2_2
XFILLER_0_28_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3613_ _0654_ _0885_ _0886_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__o22a_1
XFILLER_0_43_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4593_ _1650_ net525 VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__and2_1
X_3544_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__buf_2
XFILLER_0_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3475_ _0745_ _0760_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2426_ _2115_ _2117_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__nand2_1
X_5214_ clknet_3_4__leaf_clk _0050_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_5145_ _2072_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_71_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5076_ _2036_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_4027_ net300 net219 VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__and2_1
XFILLER_0_136_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4929_ _1936_ _1937_ VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_132_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_375 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3260_ _0582_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_2
X_3191_ sm2.s2.t1.A_wire\[5\] VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4714_ _0444_ _0310_ _0299_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__and3_1
X_2975_ _0335_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__and2_2
XFILLER_0_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_347 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4645_ _1716_ _1693_ _1722_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_71_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4576_ net238 net321 VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3527_ _0772_ _0816_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_116_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3458_ sm1.s2.t1.A_wire\[3\] _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__xor2_4
X_2409_ net27 _2082_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_110_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3389_ _0683_ _0687_ _0694_ _0690_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a221o_1
X_5128_ _2063_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_5059_ _2027_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_127_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_124_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2760_ _0067_ net37 _2120_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_115_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2691_ _2085_ _2357_ _0074_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_100_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_2 _1124_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4430_ _0409_ _0416_ _0340_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4361_ net196 net209 VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3312_ _0552_ _0599_ _0603_ _0554_ _2187_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a221o_1
X_4292_ _1311_ _0568_ _1313_ _0571_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3243_ _0515_ _0513_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and3_1
X_3174_ _0503_ _0504_ _0505_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_83_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_20_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4628_ _1697_ _1708_ VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2889_ _0259_ VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4559_ net247 _0436_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_129_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_301 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3930_ net297 net216 VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3861_ _0693_ _0907_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2812_ _2089_ _0102_ _0188_ _0191_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__o22a_2
XFILLER_0_116_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3792_ _1041_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__inv_2
X_2743_ sm2.s2.t2.A_wire\[10\] VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2674_ _0067_ net37 _0068_ _0069_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__a31o_1
XFILLER_0_78_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4413_ net384 net398 VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_113_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4344_ _1472_ _1474_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_94_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4275_ _1423_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__and2b_1
X_3226_ _0551_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__and2_2
X_3157_ _0270_ _0469_ _0489_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__o22a_1
XFILLER_0_96_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3088_ _0373_ _0396_ _0411_ _0361_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_124_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_130_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_359 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_138_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_212 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2390_ _2109_ _2099_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__o21ai_1
X_4060_ _1254_ _1255_ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_39_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3011_ _0320_ _0317_ _0367_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a31o_1
XFILLER_0_86_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4962_ net440 net455 _1958_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_19_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_129_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4893_ net426 net412 VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__or2_1
X_3913_ _1115_ net486 VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3844_ net292 net211 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__xor2_4
XFILLER_0_129_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3775_ net24 _2210_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__and2_1
X_2726_ sm2.s2.t2.A_wire\[8\] VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2657_ _2089_ _2261_ _2348_ _2350_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__o22a_1
Xoutput410 net410 VGND VGND VPWR VPWR partial_sum14_2[13] sky130_fd_sc_hd__buf_1
XFILLER_0_42_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput421 net421 VGND VGND VPWR VPWR partial_sum14_3[10] sky130_fd_sc_hd__buf_1
Xoutput443 net443 VGND VGND VPWR VPWR partial_sum15[4] sky130_fd_sc_hd__buf_1
Xoutput432 net432 VGND VGND VPWR VPWR partial_sum14_3[8] sky130_fd_sc_hd__buf_1
Xoutput487 net487 VGND VGND VPWR VPWR sum_out1[5] sky130_fd_sc_hd__buf_1
X_2588_ _2089_ _2213_ _2208_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__and3_1
Xoutput465 net465 VGND VGND VPWR VPWR partial_sum16[10] sky130_fd_sc_hd__buf_1
Xoutput454 net454 VGND VGND VPWR VPWR partial_sum15_1[14] sky130_fd_sc_hd__buf_1
Xoutput476 net476 VGND VGND VPWR VPWR partial_sum16[6] sky130_fd_sc_hd__buf_1
Xoutput498 net498 VGND VGND VPWR VPWR sum_out2[4] sky130_fd_sc_hd__buf_1
X_4327_ _1460_ _1462_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nor2_1
X_4258_ _1409_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__nor2_2
X_3209_ _0536_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_2_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4189_ _0108_ net372 VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_126_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3560_ _0782_ _0834_ _0847_ _0757_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2511_ net25 _2222_ _2214_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3491_ _0787_ _0759_ _0772_ _0782_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2442_ sm2.s1.t2.A_wire\[7\] _2135_ _2155_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_110_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5161_ _2080_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_2373_ net26 net27 VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4112_ _1103_ _1104_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__nand2_4
X_5092_ _2044_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4043_ net481 _1234_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4945_ net423 net409 VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_136_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4876_ net542 _1895_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3827_ _1070_ _1071_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__xor2_4
XFILLER_0_61_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3758_ net257 net342 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2_1
X_2709_ sm2.s2.t2.A_wire\[6\] VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__buf_2
XFILLER_0_30_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3689_ _2118_ _0946_ _0945_ _2116_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__a221o_1
XFILLER_0_100_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput240 net240 VGND VGND VPWR VPWR out1_4[10] sky130_fd_sc_hd__buf_1
Xoutput251 net251 VGND VGND VPWR VPWR out1_5[1] sky130_fd_sc_hd__buf_1
Xoutput262 net262 VGND VGND VPWR VPWR out1_6[2] sky130_fd_sc_hd__buf_1
Xoutput273 net273 VGND VGND VPWR VPWR out1_7[3] sky130_fd_sc_hd__buf_1
Xoutput284 net284 VGND VGND VPWR VPWR out1_8[4] sky130_fd_sc_hd__buf_1
Xoutput295 net295 VGND VGND VPWR VPWR out2[4] sky130_fd_sc_hd__buf_1
XFILLER_0_100_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_123_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2991_ _0331_ _0337_ _0334_ _0347_ _0328_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_14_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4730_ net347 net261 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__xor2_4
XFILLER_0_83_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_126_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4661_ _1709_ _1712_ _1735_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3612_ _0649_ net2 VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xor2_1
XFILLER_0_101_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4592_ net526 _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__xor2_2
X_3543_ _0830_ _0764_ _2093_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and3b_1
XFILLER_0_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3474_ _0756_ _0771_ _0772_ _0758_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2425_ _2122_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__buf_4
X_5213_ clknet_3_1__leaf_clk _0049_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5144_ _2270_ net79 _2067_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_71_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5075_ _0703_ net46 _2034_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__mux2_1
X_4026_ _1229_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_32_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4928_ _1493_ _1872_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_82_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4859_ net551 _1867_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_10_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_41_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_122_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3190_ sm2.s2.t1.A_wire\[3\] sm2.s2.t1.A_wire\[4\] sm2.s2.t1.A_wire\[5\] VGND VGND
+ VPWR VPWR _0521_ sky130_fd_sc_hd__or3_1
XFILLER_0_56_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2974_ sm1.s2.t2.A_wire\[3\] _0319_ _0326_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4713_ _1733_ VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__inv_2
XFILLER_0_44_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4644_ net505 _1721_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4575_ _1634_ net513 VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3526_ _0818_ VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_116_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3457_ sm1.s2.t1.A_wire\[4\] VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__buf_4
X_2408_ net27 _2113_ _2083_ _2099_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__and4_1
X_3388_ _0695_ _0660_ _0661_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__and3_1
X_5127_ _0123_ net103 _2056_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__mux2_1
XFILLER_0_98_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5058_ _0358_ net70 _2023_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4009_ _1214_ _1195_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_127_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_132_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_95_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2690_ sm2.s2.t2.A_wire\[3\] _0082_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_100_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 _1482_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4360_ _1487_ _1489_ VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__xor2_2
XFILLER_0_111_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3311_ _0562_ _0594_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__and2_1
X_4291_ _1437_ _1438_ VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__xnor2_4
XFILLER_0_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3242_ _0566_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__nor2_2
X_3173_ _0496_ _0498_ _0497_ _0500_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_83_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2957_ net20 VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_20_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2888_ _0254_ _0256_ _0258_ _0217_ _2086_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__o32a_1
XFILLER_0_114_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4627_ net144 net157 VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_130_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4558_ _0305_ _0353_ _1539_ _0352_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a22o_2
X_3509_ _0803_ _0759_ _0774_ _0793_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4489_ _1544_ _1545_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_129_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_471 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3860_ net497 _1090_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__xnor2_4
X_2811_ _0105_ _0177_ _0189_ _0190_ _2188_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__a2111o_1
X_3791_ _1039_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__xnor2_4
X_2742_ sm2.s2.t2.A_wire\[10\] _0124_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__or2_2
XFILLER_0_82_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2673_ net38 net40 net36 net37 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__and4b_1
XFILLER_0_112_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4412_ net384 net398 VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__and2_1
XFILLER_0_111_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4343_ _1331_ _1338_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__nor2_1
X_4274_ _1421_ _1422_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nand2_1
X_3225_ _0546_ _0536_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_118_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3156_ _0285_ _0463_ _0490_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3087_ _0358_ _0408_ _0432_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_6_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3989_ _1197_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_130_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_138_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_130_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3010_ _0366_ _0322_ _0333_ _0358_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4961_ _1960_ _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_19_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_452 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3912_ _1131_ _1134_ VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__xor2_4
X_4892_ net426 net412 VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3843_ net303 net221 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__xor2_4
XFILLER_0_116_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3774_ _1025_ _1026_ VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__xnor2_4
XFILLER_0_120_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2725_ _0109_ _0097_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2656_ _2265_ _2328_ _2329_ _2270_ _2349_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__a221o_1
Xoutput411 net411 VGND VGND VPWR VPWR partial_sum14_2[1] sky130_fd_sc_hd__buf_1
Xoutput400 net400 VGND VGND VPWR VPWR partial_sum14_1[4] sky130_fd_sc_hd__buf_1
Xoutput433 net433 VGND VGND VPWR VPWR partial_sum14_3[9] sky130_fd_sc_hd__buf_1
Xoutput422 net422 VGND VGND VPWR VPWR partial_sum14_3[11] sky130_fd_sc_hd__buf_1
Xoutput444 net444 VGND VGND VPWR VPWR partial_sum15[5] sky130_fd_sc_hd__buf_1
Xoutput455 net455 VGND VGND VPWR VPWR partial_sum15_1[1] sky130_fd_sc_hd__buf_1
Xoutput477 net477 VGND VGND VPWR VPWR partial_sum16[7] sky130_fd_sc_hd__buf_1
Xoutput466 net466 VGND VGND VPWR VPWR partial_sum16[11] sky130_fd_sc_hd__buf_1
X_2587_ _2289_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_2
Xoutput499 net499 VGND VGND VPWR VPWR sum_out2[5] sky130_fd_sc_hd__buf_1
Xoutput488 net488 VGND VGND VPWR VPWR sum_out1[6] sky130_fd_sc_hd__buf_1
X_4326_ _1460_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__and2_1
X_4257_ _0138_ _0202_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__nor2_1
X_4188_ _1315_ _0094_ _1317_ _0092_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a22o_1
X_3208_ _0537_ _0521_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_2_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3139_ _0477_ VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__inv_2
XFILLER_0_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_137_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_78_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3490_ sm1.s2.t1.A_wire\[7\] VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__buf_4
X_2510_ net21 _2211_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__or2_1
X_2441_ sm2.s1.t2.A_wire\[7\] sm2.s1.t2.A_wire\[8\] _2135_ VGND VGND VPWR VPWR _2159_
+ sky130_fd_sc_hd__or3_1
XFILLER_0_59_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5160_ _2168_ net87 _2011_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__mux2_1
X_2372_ _2093_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_87_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4111_ _1294_ VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__inv_2
X_5091_ _0261_ net54 _2034_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__mux2_1
X_4042_ net481 _1234_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__nor2_1
XFILLER_0_115_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4944_ _1948_ _1949_ VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__xor2_2
XFILLER_0_115_84 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_271 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4875_ _1891_ _1896_ VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__xnor2_4
XFILLER_0_74_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3826_ _1022_ _1062_ _1064_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__o21ai_4
X_3757_ _1012_ VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__inv_2
XFILLER_0_27_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2708_ _0094_ _0095_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3688_ _2126_ _0942_ _0951_ _2092_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_76_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_132_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2639_ _2265_ _2301_ _2324_ _2257_ _2144_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__a221o_1
Xoutput230 net230 VGND VGND VPWR VPWR out1_3[10] sky130_fd_sc_hd__buf_1
Xoutput241 net241 VGND VGND VPWR VPWR out1_4[1] sky130_fd_sc_hd__buf_1
Xoutput252 net252 VGND VGND VPWR VPWR out1_5[2] sky130_fd_sc_hd__buf_1
XFILLER_0_30_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput263 net263 VGND VGND VPWR VPWR out1_6[3] sky130_fd_sc_hd__buf_1
Xoutput274 net274 VGND VGND VPWR VPWR out1_7[4] sky130_fd_sc_hd__buf_1
Xoutput285 net285 VGND VGND VPWR VPWR out1_8[5] sky130_fd_sc_hd__buf_1
XFILLER_0_49_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4309_ net270 net357 VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__nor2_1
Xoutput296 net296 VGND VGND VPWR VPWR out2[5] sky130_fd_sc_hd__buf_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_135_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_557 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2990_ _0350_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
X_4660_ _1278_ net405 VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__and2b_1
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_126_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3611_ _0672_ _0887_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__and2b_2
XFILLER_0_126_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4591_ _0305_ _0361_ _1539_ _0358_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3542_ _2083_ _0764_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__and3_2
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3473_ net15 _0760_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__and2_2
XFILLER_0_12_569 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2424_ _2140_ _2104_ _2114_ _2126_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__a221o_1
X_5212_ clknet_3_1__leaf_clk _0048_ VGND VGND VPWR VPWR sm2.s1.t1.A_wire\[3\] sky130_fd_sc_hd__dfxtp_2
X_5143_ _2071_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_71_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5074_ _2035_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4025_ net291 net210 VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or2_2
XFILLER_0_126_72 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4927_ _1932_ _1934_ _1935_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4858_ _1882_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_82_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3809_ _2296_ _2265_ _1028_ _2261_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4789_ _1041_ net179 VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_127_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_105_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2973_ sm1.s2.t2.A_wire\[3\] sm1.s2.t2.A_wire\[4\] sm1.s2.t2.A_wire\[5\] VGND VGND
+ VPWR VPWR _0335_ sky130_fd_sc_hd__or3_1
X_4712_ _1602_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__inv_2
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4643_ _0742_ _0809_ _1532_ _0807_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4574_ _1647_ _1654_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3525_ _0803_ _0777_ _0815_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_116_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3456_ net15 _0754_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and2_2
X_2407_ _2126_ _2104_ _2114_ _2116_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__a22o_1
X_3387_ sm1.s1.t1.A_wire\[7\] VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_4
X_5126_ _2062_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5057_ _2026_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_4008_ net490 _1192_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_127_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_132_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_585 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_59_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_4 _1645_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_111_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3310_ _0627_ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ _1417_ _1420_ _1418_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__o21a_2
XFILLER_0_67_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3241_ sm2.s2.t1.A_wire\[10\] _0559_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nor2_1
X_3172_ _0497_ _0498_ _0500_ _0496_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__and4b_1
XPHY_EDGE_ROW_60_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2956_ sm1.s2.t2.A_wire\[4\] VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2887_ _0257_ _0247_ _0248_ _0218_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4626_ _1704_ _1707_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__xor2_4
XFILLER_0_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4557_ _1620_ _1628_ _1648_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a21o_2
X_3508_ sm1.s2.t1.A_wire\[9\] VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4488_ _1574_ _1575_ _1592_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__a21o_2
X_3439_ _0738_ net15 net13 net11 VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_129_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5109_ _2053_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_28_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_137_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_133_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_179 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_128_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_450 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_128_213 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2810_ _0126_ _0156_ _0179_ _0109_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__a22o_1
X_3790_ _1030_ _1033_ _1032_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_26_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2741_ _0130_ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__inv_2
XFILLER_0_14_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2672_ net38 net40 net39 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a21o_1
X_4411_ _1524_ _1526_ VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__xor2_2
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4342_ net192 net205 VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__xor2_1
X_4273_ _1421_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nor2_1
X_3224_ sm2.s2.t1.A_wire\[8\] VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__buf_2
.ends
